Properties of the parts of a building model (IFC4), part 5 of 10

# IfcBuildingElementPart (358)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | CHICAGO Palanca Azul H-H | STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1349424 | Accessoire de canalisation | 2021_015 | Autre - Famille et type: CHICAGO Palanca Azul H-H; Famille: CHICAGO Palanca Azul H-H; Type: CHICAGO Palanca Azul H-H; ID du type: CHICAGO Palanca Azul H-H; CRP: 10004; C1: 4; C2: 1; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FAUCET; Exporter au format IFC sous: IfcValveType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000392733 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; D2: 0.0135 m; DN: 0.015 m; RN: 0.0075 m; DN (pulgadas): 1/2''; A: 0.046 m; B: 0.095 m; h: 0.046 m; h1: 0.0328 m; D1: 0.031 m; R1: 0.0155 m; A1: 0.01156 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.499999 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 921729; Nom: CHICAGO Palanca Azul H-H; Elévation par défaut: 0 m; Catégorie: Accessoire de canalisation; Exporter le type au format IFC: 0; Modèle: Válvula de esfera roscar CHICAGO palanca H-H; Fabricant: STH STANDARD HIDRAULICA; URL: http://www.standardhidraulica.com/; Description: Válvula de esfera roscar CHICAGO palanca H-H. Adecuada para agua fría, ACS y aire. Zonas en contacto con el fluido, no cromado. Producto básico y funcional; Titre OmniClass: Adjusting/Controlling Valves for Liquid Services; Numéro OmniClass: 23.65.55.14.17; Sous-projet: Famille : Accessoire de canalisation : STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom de la famille: STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom du type: CHICAGO Palanca Azul H-H; Type: Type prédéfini d'IFC: CHECK; Exporter le type au format IFC sous: IfcValveType; IfcExportAs: IfcValveType; IfcExportType: CHECK; Coefficient K: 0; Normativa UNE (accesorios): UNE-EN 12.164-12.165; BIMETRICAL Category: Valve; Versión Familia: 1.0; Versión Revit: Revit 2016 - Español; Fecha de Revisión: 09/2017; Creado por: BIMETRICAL; BIMETRICAL: http://www.bimetrical.com/; Nombre_Lookup_Cotas: STH Valvula Esfera Palanca H-H CHICAGO - Cotas; PN: PN 25; Temperatura: -10 ºC a 110 ºC; Nombre_Lookup_Referencia: STH Valvula Esfera Palanca H-H CHICAGO - Referencia; Material cuerpo: STH_Latón Acabado Niquelado; Material palanca: STH_Aluminio; G: 0.008 m; Color palanca: STH_Palanca Azul; G1: 0.0073 m; Palanca Azul: yes; Palanca Roja: no; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes; Données d'identification - Referencia Producto: 34501; Código: 34501
STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | CHICAGO Palanca Azul H-H | STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1378024 | Accessoire de canalisation | 2021_015 | Autre - Famille et type: CHICAGO Palanca Azul H-H; Famille: CHICAGO Palanca Azul H-H; Type: CHICAGO Palanca Azul H-H; ID du type: CHICAGO Palanca Azul H-H; CRP: 10016; C1: 16; C2: 1; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FAUCET; Exporter au format IFC sous: IfcValveType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000816793 m3; Taille: ø25 mm-ø25 mm; Taille maximale: 0.025 m; Taille minimale: 0.025 m; D2: 0.0135 m; DN: 0.025 m; RN: 0.0125 m; DN (pulgadas): 1''; A: 0.061 m; B: 0.104 m; h: 0.057 m; h1: 0.0415 m; D1: 0.041 m; R1: 0.0205 m; A1: 0.01456 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 2.69998 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 921729; Nom: CHICAGO Palanca Azul H-H; Elévation par défaut: 0 m; Catégorie: Accessoire de canalisation; Exporter le type au format IFC: 0; Modèle: Válvula de esfera roscar CHICAGO palanca H-H; Fabricant: STH STANDARD HIDRAULICA; URL: http://www.standardhidraulica.com/; Description: Válvula de esfera roscar CHICAGO palanca H-H. Adecuada para agua fría, ACS y aire. Zonas en contacto con el fluido, no cromado. Producto básico y funcional; Titre OmniClass: Adjusting/Controlling Valves for Liquid Services; Numéro OmniClass: 23.65.55.14.17; Sous-projet: Famille : Accessoire de canalisation : STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom de la famille: STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom du type: CHICAGO Palanca Azul H-H; Type: Type prédéfini d'IFC: CHECK; Exporter le type au format IFC sous: IfcValveType; IfcExportAs: IfcValveType; IfcExportType: CHECK; Coefficient K: 0; Normativa UNE (accesorios): UNE-EN 12.164-12.165; BIMETRICAL Category: Valve; Versión Familia: 1.0; Versión Revit: Revit 2016 - Español; Fecha de Revisión: 09/2017; Creado por: BIMETRICAL; BIMETRICAL: http://www.bimetrical.com/; Nombre_Lookup_Cotas: STH Valvula Esfera Palanca H-H CHICAGO - Cotas; PN: PN 25; Temperatura: -10 ºC a 110 ºC; Nombre_Lookup_Referencia: STH Valvula Esfera Palanca H-H CHICAGO - Referencia; Material cuerpo: STH_Latón Acabado Niquelado; Material palanca: STH_Aluminio; G: 0.008 m; Color palanca: STH_Palanca Azul; G1: 0.0073 m; Palanca Azul: yes; Palanca Roja: no; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm-ø25 mm; Graphismes - Utiliser l'échelle d'annotations: yes; Données d'identification - Referencia Producto: 34503; Código: 34503
Canalisation souple | Category | Canalisation souple | N0 FINI
Canalisation souple arrondie | Family | Canalisation souple arrondie | N0 FINI
2 x Souple - Circulaire | Type | Souple - Circulaire | N0 FINI
Canalisation souple arrondie | Souple - Circulaire | Canalisation souple arrondie | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345333 | Canalisation souple | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Diamètre: 0.015 m; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142445; Nom: Souple - Circulaire; Catégorie: Canalisation souple; Exporter le type au format IFC: 0; Sous-projet: Types de canalisations souples; Nom de la famille: Canalisation souple arrondie; Nom du type: Souple - Circulaire; Rugosité: 0.00004572 m; Type de jonction préférée: 1; Union: Standard; Transition: Standard; Té: Standard; Génie climatique - Débit - Débit: 0.1 L/s; Pression dynamique: 313.5 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 10588.5; Rugosité relative: 0.003048; Etat du flux: 2; Facteur de frottement: 0.0348322; Vitesse: 0.8 m/s; Frottement: 727.94 Pa/m; Perte de pression: 489.7 Pa; Tronçon: 62; Contraintes - Élévation centrale de départ: 1.1305 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Cotes - Epaisseur de paroi: 0 m; Diamètre extérieur: 0.015 m; Diamètre intérieur: 0.015 m; Longueur: 0.672773 m; Graphismes - Modèle de gaine flexible: 0
Canalisation souple arrondie | Souple - Circulaire | Canalisation souple arrondie | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345336 | Canalisation souple | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Diamètre: 0.015 m; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142445; Nom: Souple - Circulaire; Catégorie: Canalisation souple; Exporter le type au format IFC: 0; Sous-projet: Types de canalisations souples; Nom de la famille: Canalisation souple arrondie; Nom du type: Souple - Circulaire; Rugosité: 0.00004572 m; Type de jonction préférée: 1; Union: Standard; Transition: Standard; Té: Standard; Génie climatique - Débit - Débit: 0.1 L/s; Pression dynamique: 313.5 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 10588.5; Rugosité relative: 0.003048; Etat du flux: 2; Facteur de frottement: 0.0348322; Vitesse: 0.8 m/s; Frottement: 727.94 Pa/m; Perte de pression: 481.2 Pa; Tronçon: 61; Contraintes - Élévation centrale de départ: 0.589499 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Cotes - Epaisseur de paroi: 0 m; Diamètre extérieur: 0.015 m; Diamètre intérieur: 0.015 m; Longueur: 0.661098 m; Graphismes - Modèle de gaine flexible: 0
Canalisation souple arrondie | Souple - Circulaire | Canalisation souple arrondie | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345339 | Canalisation souple | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Diamètre: 0.015 m; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142445; Nom: Souple - Circulaire; Catégorie: Canalisation souple; Exporter le type au format IFC: 0; Sous-projet: Types de canalisations souples; Nom de la famille: Canalisation souple arrondie; Nom du type: Souple - Circulaire; Rugosité: 0.00004572 m; Type de jonction préférée: 1; Union: Standard; Transition: Standard; Té: Standard; Génie climatique - Débit - Débit: 0.1 L/s; Pression dynamique: 313.5 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 10588.5; Rugosité relative: 0.003048; Etat du flux: 2; Facteur de frottement: 0.0348322; Vitesse: 0.8 m/s; Frottement: 727.94 Pa/m; Perte de pression: 484.9 Pa; Tronçon: 63; Contraintes - Élévation centrale de départ: 0.602499 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Cotes - Epaisseur de paroi: 0 m; Diamètre extérieur: 0.015 m; Diamètre intérieur: 0.015 m; Longueur: 0.666094 m; Graphismes - Modèle de gaine flexible: 0
Canalisation souple arrondie | Souple - Circulaire | Canalisation souple arrondie | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345964 | Canalisation souple | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Diamètre: 0.01 m; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142445; Nom: Souple - Circulaire; Catégorie: Canalisation souple; Exporter le type au format IFC: 0; Sous-projet: Types de canalisations souples; Nom de la famille: Canalisation souple arrondie; Nom du type: Souple - Circulaire; Rugosité: 0.00004572 m; Type de jonction préférée: 1; Union: Standard; Transition: Standard; Té: Standard; Génie climatique - Débit - Débit: 0.1 L/s; Pression dynamique: 202.4 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 5672.43; Rugosité relative: 0.004572; Etat du flux: 2; Facteur de frottement: 0.0411039; Vitesse: 0.6 m/s; Frottement: 832.03 Pa/m; Perte de pression: 216.9 Pa; Tronçon: 66; Contraintes - Élévation centrale de départ: 0.720555 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø10 mm; Cotes - Epaisseur de paroi: 0 m; Diamètre extérieur: 0.01 m; Diamètre intérieur: 0.01 m; Longueur: 0.260739 m; Graphismes - Modèle de gaine flexible: 0
Canalisation souple arrondie | Souple - Circulaire | Canalisation souple arrondie | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1346062 | Canalisation souple | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Diamètre: 0.01 m; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142445; Nom: Souple - Circulaire; Catégorie: Canalisation souple; Exporter le type au format IFC: 0; Sous-projet: Types de canalisations souples; Nom de la famille: Canalisation souple arrondie; Nom du type: Souple - Circulaire; Rugosité: 0.00004572 m; Type de jonction préférée: 1; Union: Standard; Transition: Standard; Té: Standard; Génie climatique - Débit - Débit: 0.1 L/s; Pression dynamique: 202.4 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 5672.43; Rugosité relative: 0.004572; Etat du flux: 2; Facteur de frottement: 0.0411039; Vitesse: 0.6 m/s; Frottement: 832.03 Pa/m; Perte de pression: 210.8 Pa; Tronçon: 68; Contraintes - Élévation centrale de départ: 0.720555 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø10 mm; Cotes - Epaisseur de paroi: 0 m; Diamètre extérieur: 0.01 m; Diamètre intérieur: 0.01 m; Longueur: 0.253297 m; Graphismes - Modèle de gaine flexible: 0
Canalisation souple arrondie | Souple - Circulaire | Canalisation souple arrondie | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1346203 | Canalisation souple | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Diamètre: 0.01 m; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142445; Nom: Souple - Circulaire; Catégorie: Canalisation souple; Exporter le type au format IFC: 0; Sous-projet: Types de canalisations souples; Nom de la famille: Canalisation souple arrondie; Nom du type: Souple - Circulaire; Rugosité: 0.00004572 m; Type de jonction préférée: 1; Union: Standard; Transition: Standard; Té: Standard; Génie climatique - Débit - Débit: 0.1 L/s; Pression dynamique: 202.4 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 5672.43; Rugosité relative: 0.004572; Etat du flux: 2; Facteur de frottement: 0.0411039; Vitesse: 0.6 m/s; Frottement: 832.03 Pa/m; Perte de pression: 212.9 Pa; Tronçon: 70; Contraintes - Élévation centrale de départ: 0.720555 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø10 mm; Cotes - Epaisseur de paroi: 0 m; Diamètre extérieur: 0.01 m; Diamètre intérieur: 0.01 m; Longueur: 0.255931 m; Graphismes - Modèle de gaine flexible: 0
Equipement de génie climatique | Category | Equipement de génie climatique | N0 FINI
202_RADIATEUR GENERIQUE | Family | 202_RADIATEUR GENERIQUE | N0 FINI
Type | Type | Type | N0 FINI
202_RADIATEUR GENERIQUE | Type | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1459479 | Equipement de génie climatique | 2021_015 | Autre - Famille et type: Type; Famille: Type; Type: Type; ID du type: Type; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RADIATOR; Exporter au format IFC sous: IfcSpaceHeaterType; Revizto - Architecture: yes; Plumbing: yes; Mechanical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Retour hydraulique,Alimentation hydraulique; Corrected Output: 269; Delta T_MWT Room: 50; Flow Temp: 75; Mean Water Temp: 70; Return Temp: 65; Room Temp: 20; Cotes - Volume: 0.0756711 m3; Surface: 1.40418 m2; Connection Radius: 0.0075 m; Connection Diameter: 0.015 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.2 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.2 m; Angle: 0 deg; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.3.6; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1480591; Nom: Type; Elévation par défaut: 0 m; Note d'identification: 200_CHAUFFAGE; Catégorie: Equipement de génie climatique; Exporter le type au format IFC: 0; Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Sous-projet: Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE; Nom de la famille: 202_RADIATEUR GENERIQUE; Nom du type: Type; Depth: 0.067 m; Height: 2 m; Classification: 0; Length: 0.62 m; _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Offset From Wall: 0.017 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Weight: 4; Water Volume: 0.31; Product Family: Wall Mounted; Heating Element Type: 6; EN442 Output DT50: 269; N_Value: 1.41; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; ROP_SUIVIE DE CHANTIER - Installation ?: no; Matériaux et finitions - Radiator Finish: Jaga - RAL 9016 - Traffic White - 233; Valve Finish: Jaga - RAL 9016 - Traffic White - 233; Construction - Valve Configuration_Floor: yes; Valve Configuration_Wall: no; Général - Connection Set: User to input 'Connection Set' code; Visibilité - External TRV Head: no; Right Valve: no; Left Valve: no; Génie climatique - Débit - Density of Fluid: 1000; Mass Flow Rate_kgPerHr: 23.1287; Mass Flow Rate_kgPerS: 0.00642465; Pressure Drop Value: 0.194434; Pressure Drop_Radiator: 0.0458402; Pressure Drop_Valve: 0.148594; Specific Heat Capacity: 4187; Temp Difference: 10; Valve Flow Factor Kv: 0.6; Flow Rate: 0.0 L/s; Pressure Drop: 45.8 Pa; Electrique - Position 4 8: no; Position 1 5: no; Position 4 5: no; Position M M: yes; Position 1 8: no; Position 8 1: no; valve height: 0.06 m; Connector Flow Height: 0.03 m; Connector Return Height: 0.03 m; Connector Return Dist: 0.295 m; Connector Flow Dist: 0.325 m
12 x 202_RADIATEUR GENERIQUE | Instance | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1480591 | Equipement de génie climatique | Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE | Autre - Nom de la famille: 202_RADIATEUR GENERIQUE; Données d'identification - Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Nom du type: Type; Note d'identification: 200_CHAUFFAGE; Product Family: Wall Mounted; Contraintes - Elévation par défaut: 0 m; Offset From Wall: 0.017 m; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Depth: 0.067 m; Height: 2 m; Length: 0.62 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Génie climatique - Classification: 0; EN442 Output DT50: 269; N_Value: 1.41; Général - _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Données - Weight: 4; Water Volume: 0.31; Heating Element Type: 6
202_RADIATEUR GENERIQUE | Type | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1459504 | Equipement de génie climatique | 2021_015 | Autre - Famille et type: Type; Famille: Type; Type: Type; ID du type: Type; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RADIATOR; Exporter au format IFC sous: IfcSpaceHeaterType; Revizto - Architecture: yes; Plumbing: yes; Mechanical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Retour hydraulique,Alimentation hydraulique; Corrected Output: 269; Delta T_MWT Room: 50; Flow Temp: 75; Mean Water Temp: 70; Return Temp: 65; Room Temp: 20; Cotes - Volume: 0.0756711 m3; Surface: 1.40418 m2; Connection Radius: 0.0075 m; Connection Diameter: 0.015 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.2 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.2 m; Angle: 0 deg; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.3.6; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1480591; Nom: Type; Elévation par défaut: 0 m; Note d'identification: 200_CHAUFFAGE; Catégorie: Equipement de génie climatique; Exporter le type au format IFC: 0; Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Sous-projet: Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE; Nom de la famille: 202_RADIATEUR GENERIQUE; Nom du type: Type; Depth: 0.067 m; Height: 2 m; Classification: 0; Length: 0.62 m; _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Offset From Wall: 0.017 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Weight: 4; Water Volume: 0.31; Product Family: Wall Mounted; Heating Element Type: 6; EN442 Output DT50: 269; N_Value: 1.41; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; ROP_SUIVIE DE CHANTIER - Installation ?: no; Matériaux et finitions - Radiator Finish: Jaga - RAL 9016 - Traffic White - 233; Valve Finish: Jaga - RAL 9016 - Traffic White - 233; Construction - Valve Configuration_Floor: yes; Valve Configuration_Wall: no; Général - Connection Set: User to input 'Connection Set' code; Visibilité - External TRV Head: no; Right Valve: no; Left Valve: no; Génie climatique - Débit - Density of Fluid: 1000; Mass Flow Rate_kgPerHr: 23.1287; Mass Flow Rate_kgPerS: 0.00642465; Pressure Drop Value: 0.194434; Pressure Drop_Radiator: 0.0458402; Pressure Drop_Valve: 0.148594; Specific Heat Capacity: 4187; Temp Difference: 10; Valve Flow Factor Kv: 0.6; Flow Rate: 0.0 L/s; Pressure Drop: 45.8 Pa; Electrique - Position 4 8: no; Position 1 5: no; Position 4 5: no; Position M M: yes; Position 1 8: no; Position 8 1: no; valve height: 0.06 m; Connector Flow Height: 0.03 m; Connector Return Height: 0.03 m; Connector Return Dist: 0.295 m; Connector Flow Dist: 0.325 m
202_RADIATEUR GENERIQUE | Type | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1459527 | Equipement de génie climatique | 2021_015 | Autre - Famille et type: Type; Famille: Type; Type: Type; ID du type: Type; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RADIATOR; Exporter au format IFC sous: IfcSpaceHeaterType; Revizto - Architecture: yes; Plumbing: yes; Mechanical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Retour hydraulique,Alimentation hydraulique; Corrected Output: 269; Delta T_MWT Room: 50; Flow Temp: 75; Mean Water Temp: 70; Return Temp: 65; Room Temp: 20; Cotes - Volume: 0.0756711 m3; Surface: 1.40418 m2; Connection Radius: 0.0075 m; Connection Diameter: 0.015 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.2 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.2 m; Angle: 0 deg; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.3.6; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1480591; Nom: Type; Elévation par défaut: 0 m; Note d'identification: 200_CHAUFFAGE; Catégorie: Equipement de génie climatique; Exporter le type au format IFC: 0; Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Sous-projet: Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE; Nom de la famille: 202_RADIATEUR GENERIQUE; Nom du type: Type; Depth: 0.067 m; Height: 2 m; Classification: 0; Length: 0.62 m; _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Offset From Wall: 0.017 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Weight: 4; Water Volume: 0.31; Product Family: Wall Mounted; Heating Element Type: 6; EN442 Output DT50: 269; N_Value: 1.41; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; ROP_SUIVIE DE CHANTIER - Installation ?: no; Matériaux et finitions - Radiator Finish: Jaga - RAL 9016 - Traffic White - 233; Valve Finish: Jaga - RAL 9016 - Traffic White - 233; Construction - Valve Configuration_Floor: yes; Valve Configuration_Wall: no; Général - Connection Set: User to input 'Connection Set' code; Visibilité - External TRV Head: no; Right Valve: no; Left Valve: no; Génie climatique - Débit - Density of Fluid: 1000; Mass Flow Rate_kgPerHr: 23.1287; Mass Flow Rate_kgPerS: 0.00642465; Pressure Drop Value: 0.194434; Pressure Drop_Radiator: 0.0458402; Pressure Drop_Valve: 0.148594; Specific Heat Capacity: 4187; Temp Difference: 10; Valve Flow Factor Kv: 0.6; Flow Rate: 0.0 L/s; Pressure Drop: 45.8 Pa; Electrique - Position 4 8: no; Position 1 5: no; Position 4 5: no; Position M M: yes; Position 1 8: no; Position 8 1: no; valve height: 0.06 m; Connector Flow Height: 0.03 m; Connector Return Height: 0.03 m; Connector Return Dist: 0.295 m; Connector Flow Dist: 0.325 m
202_RADIATEUR GENERIQUE | Type | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1459550 | Equipement de génie climatique | 2021_015 | Autre - Famille et type: Type; Famille: Type; Type: Type; ID du type: Type; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RADIATOR; Exporter au format IFC sous: IfcSpaceHeaterType; Revizto - Architecture: yes; Plumbing: yes; Mechanical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Retour hydraulique,Alimentation hydraulique; Corrected Output: 269; Delta T_MWT Room: 50; Flow Temp: 75; Mean Water Temp: 70; Return Temp: 65; Room Temp: 20; Cotes - Volume: 0.0756711 m3; Surface: 1.40418 m2; Connection Radius: 0.0075 m; Connection Diameter: 0.015 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.2 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.2 m; Angle: 0 deg; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.3.6; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1480591; Nom: Type; Elévation par défaut: 0 m; Note d'identification: 200_CHAUFFAGE; Catégorie: Equipement de génie climatique; Exporter le type au format IFC: 0; Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Sous-projet: Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE; Nom de la famille: 202_RADIATEUR GENERIQUE; Nom du type: Type; Depth: 0.067 m; Height: 2 m; Classification: 0; Length: 0.62 m; _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Offset From Wall: 0.017 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Weight: 4; Water Volume: 0.31; Product Family: Wall Mounted; Heating Element Type: 6; EN442 Output DT50: 269; N_Value: 1.41; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; ROP_SUIVIE DE CHANTIER - Installation ?: no; Matériaux et finitions - Radiator Finish: Jaga - RAL 9016 - Traffic White - 233; Valve Finish: Jaga - RAL 9016 - Traffic White - 233; Construction - Valve Configuration_Floor: yes; Valve Configuration_Wall: no; Général - Connection Set: User to input 'Connection Set' code; Visibilité - External TRV Head: no; Right Valve: no; Left Valve: no; Génie climatique - Débit - Density of Fluid: 1000; Mass Flow Rate_kgPerHr: 23.1287; Mass Flow Rate_kgPerS: 0.00642465; Pressure Drop Value: 0.194434; Pressure Drop_Radiator: 0.0458402; Pressure Drop_Valve: 0.148594; Specific Heat Capacity: 4187; Temp Difference: 10; Valve Flow Factor Kv: 0.6; Flow Rate: 0.0 L/s; Pressure Drop: 45.8 Pa; Electrique - Position 4 8: no; Position 1 5: no; Position 4 5: no; Position M M: yes; Position 1 8: no; Position 8 1: no; valve height: 0.06 m; Connector Flow Height: 0.03 m; Connector Return Height: 0.03 m; Connector Return Dist: 0.295 m; Connector Flow Dist: 0.325 m
202_RADIATEUR GENERIQUE | Type | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1459576 | Equipement de génie climatique | 2021_015 | Autre - Famille et type: Type; Famille: Type; Type: Type; ID du type: Type; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RADIATOR; Exporter au format IFC sous: IfcSpaceHeaterType; Revizto - Architecture: yes; Plumbing: yes; Mechanical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Retour hydraulique,Alimentation hydraulique; Corrected Output: 269; Delta T_MWT Room: 50; Flow Temp: 75; Mean Water Temp: 70; Return Temp: 65; Room Temp: 20; Cotes - Volume: 0.0756711 m3; Surface: 1.40418 m2; Connection Radius: 0.0075 m; Connection Diameter: 0.015 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.2 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.2 m; Angle: 0 deg; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.3.6; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1480591; Nom: Type; Elévation par défaut: 0 m; Note d'identification: 200_CHAUFFAGE; Catégorie: Equipement de génie climatique; Exporter le type au format IFC: 0; Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Sous-projet: Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE; Nom de la famille: 202_RADIATEUR GENERIQUE; Nom du type: Type; Depth: 0.067 m; Height: 2 m; Classification: 0; Length: 0.62 m; _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Offset From Wall: 0.017 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Weight: 4; Water Volume: 0.31; Product Family: Wall Mounted; Heating Element Type: 6; EN442 Output DT50: 269; N_Value: 1.41; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; ROP_SUIVIE DE CHANTIER - Installation ?: no; Matériaux et finitions - Radiator Finish: Jaga - RAL 9016 - Traffic White - 233; Valve Finish: Jaga - RAL 9016 - Traffic White - 233; Construction - Valve Configuration_Floor: yes; Valve Configuration_Wall: no; Général - Connection Set: User to input 'Connection Set' code; Visibilité - External TRV Head: no; Right Valve: no; Left Valve: no; Génie climatique - Débit - Density of Fluid: 1000; Mass Flow Rate_kgPerHr: 23.1287; Mass Flow Rate_kgPerS: 0.00642465; Pressure Drop Value: 0.194434; Pressure Drop_Radiator: 0.0458402; Pressure Drop_Valve: 0.148594; Specific Heat Capacity: 4187; Temp Difference: 10; Valve Flow Factor Kv: 0.6; Flow Rate: 0.0 L/s; Pressure Drop: 45.8 Pa; Electrique - Position 4 8: no; Position 1 5: no; Position 4 5: no; Position M M: yes; Position 1 8: no; Position 8 1: no; valve height: 0.06 m; Connector Flow Height: 0.03 m; Connector Return Height: 0.03 m; Connector Return Dist: 0.295 m; Connector Flow Dist: 0.325 m
2 x 202_RADIATEUR GENERIQUE | Instance | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1480667 | Equipement de génie climatique | Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE | Autre - Nom de la famille: 202_RADIATEUR GENERIQUE; Données d'identification - Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Nom du type: Type; Note d'identification: 200_CHAUFFAGE; Product Family: Wall Mounted; Contraintes - Elévation par défaut: 0 m; Offset From Wall: 0.017 m; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Depth: 0.067 m; Height: 2 m; Length: 0.62 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Génie climatique - Classification: 0; EN442 Output DT50: 269; N_Value: 1.41; Général - _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Données - Weight: 4; Water Volume: 0.31; Heating Element Type: 6
202_RADIATEUR GENERIQUE | Type | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1459598 | Equipement de génie climatique | 2021_015 | Autre - Famille et type: Type; Famille: Type; Type: Type; ID du type: Type; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RADIATOR; Exporter au format IFC sous: IfcSpaceHeaterType; Revizto - Architecture: yes; Plumbing: yes; Mechanical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Retour hydraulique,Alimentation hydraulique; Corrected Output: 269; Delta T_MWT Room: 50; Flow Temp: 75; Mean Water Temp: 70; Return Temp: 65; Room Temp: 20; Cotes - Volume: 0.0756711 m3; Surface: 1.40418 m2; Connection Radius: 0.0075 m; Connection Diameter: 0.015 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.2 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.2 m; Angle: 0 deg; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.3.6; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1480591; Nom: Type; Elévation par défaut: 0 m; Note d'identification: 200_CHAUFFAGE; Catégorie: Equipement de génie climatique; Exporter le type au format IFC: 0; Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Sous-projet: Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE; Nom de la famille: 202_RADIATEUR GENERIQUE; Nom du type: Type; Depth: 0.067 m; Height: 2 m; Classification: 0; Length: 0.62 m; _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Offset From Wall: 0.017 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Weight: 4; Water Volume: 0.31; Product Family: Wall Mounted; Heating Element Type: 6; EN442 Output DT50: 269; N_Value: 1.41; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; ROP_SUIVIE DE CHANTIER - Installation ?: no; Matériaux et finitions - Radiator Finish: Jaga - RAL 9016 - Traffic White - 233; Valve Finish: Jaga - RAL 9016 - Traffic White - 233; Construction - Valve Configuration_Floor: yes; Valve Configuration_Wall: no; Général - Connection Set: User to input 'Connection Set' code; Visibilité - External TRV Head: no; Right Valve: no; Left Valve: no; Génie climatique - Débit - Density of Fluid: 1000; Mass Flow Rate_kgPerHr: 23.1287; Mass Flow Rate_kgPerS: 0.00642465; Pressure Drop Value: 0.194434; Pressure Drop_Radiator: 0.0458402; Pressure Drop_Valve: 0.148594; Specific Heat Capacity: 4187; Temp Difference: 10; Valve Flow Factor Kv: 0.6; Flow Rate: 0.0 L/s; Pressure Drop: 45.8 Pa; Electrique - Position 4 8: no; Position 1 5: no; Position 4 5: no; Position M M: yes; Position 1 8: no; Position 8 1: no; valve height: 0.06 m; Connector Flow Height: 0.03 m; Connector Return Height: 0.03 m; Connector Return Dist: 0.295 m; Connector Flow Dist: 0.325 m
202_RADIATEUR GENERIQUE | Type | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1459666 | Equipement de génie climatique | 2021_015 | Autre - Famille et type: Type; Famille: Type; Type: Type; ID du type: Type; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RADIATOR; Exporter au format IFC sous: IfcSpaceHeaterType; Revizto - Architecture: yes; Plumbing: yes; Mechanical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Retour hydraulique,Alimentation hydraulique; Corrected Output: 269; Delta T_MWT Room: 50; Flow Temp: 75; Mean Water Temp: 70; Return Temp: 65; Room Temp: 20; Cotes - Volume: 0.0756711 m3; Surface: 1.40418 m2; Connection Radius: 0.0075 m; Connection Diameter: 0.015 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.2 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.2 m; Angle: 0 deg; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.3.6; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1480591; Nom: Type; Elévation par défaut: 0 m; Note d'identification: 200_CHAUFFAGE; Catégorie: Equipement de génie climatique; Exporter le type au format IFC: 0; Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Sous-projet: Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE; Nom de la famille: 202_RADIATEUR GENERIQUE; Nom du type: Type; Depth: 0.067 m; Height: 2 m; Classification: 0; Length: 0.62 m; _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Offset From Wall: 0.017 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Weight: 4; Water Volume: 0.31; Product Family: Wall Mounted; Heating Element Type: 6; EN442 Output DT50: 269; N_Value: 1.41; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; ROP_SUIVIE DE CHANTIER - Installation ?: no; Matériaux et finitions - Radiator Finish: Jaga - RAL 9016 - Traffic White - 233; Valve Finish: Jaga - RAL 9016 - Traffic White - 233; Construction - Valve Configuration_Floor: yes; Valve Configuration_Wall: no; Général - Connection Set: User to input 'Connection Set' code; Visibilité - External TRV Head: no; Right Valve: no; Left Valve: no; Génie climatique - Débit - Density of Fluid: 1000; Mass Flow Rate_kgPerHr: 23.1287; Mass Flow Rate_kgPerS: 0.00642465; Pressure Drop Value: 0.194434; Pressure Drop_Radiator: 0.0458402; Pressure Drop_Valve: 0.148594; Specific Heat Capacity: 4187; Temp Difference: 10; Valve Flow Factor Kv: 0.6; Flow Rate: 0.0 L/s; Pressure Drop: 45.8 Pa; Electrique - Position 4 8: no; Position 1 5: no; Position 4 5: no; Position M M: yes; Position 1 8: no; Position 8 1: no; valve height: 0.06 m; Connector Flow Height: 0.03 m; Connector Return Height: 0.03 m; Connector Return Dist: 0.295 m; Connector Flow Dist: 0.325 m
202_RADIATEUR GENERIQUE | Type | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1459691 | Equipement de génie climatique | 2021_015 | Autre - Famille et type: Type; Famille: Type; Type: Type; ID du type: Type; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RADIATOR; Exporter au format IFC sous: IfcSpaceHeaterType; Revizto - Architecture: yes; Plumbing: yes; Mechanical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Retour hydraulique,Alimentation hydraulique; Corrected Output: 269; Delta T_MWT Room: 50; Flow Temp: 75; Mean Water Temp: 70; Return Temp: 65; Room Temp: 20; Cotes - Volume: 0.0756711 m3; Surface: 1.40418 m2; Connection Radius: 0.0075 m; Connection Diameter: 0.015 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.2 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.2 m; Angle: 0 deg; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.3.6; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1480591; Nom: Type; Elévation par défaut: 0 m; Note d'identification: 200_CHAUFFAGE; Catégorie: Equipement de génie climatique; Exporter le type au format IFC: 0; Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Sous-projet: Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE; Nom de la famille: 202_RADIATEUR GENERIQUE; Nom du type: Type; Depth: 0.067 m; Height: 2 m; Classification: 0; Length: 0.62 m; _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Offset From Wall: 0.017 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Weight: 4; Water Volume: 0.31; Product Family: Wall Mounted; Heating Element Type: 6; EN442 Output DT50: 269; N_Value: 1.41; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; ROP_SUIVIE DE CHANTIER - Installation ?: no; Matériaux et finitions - Radiator Finish: Jaga - RAL 9016 - Traffic White - 233; Valve Finish: Jaga - RAL 9016 - Traffic White - 233; Construction - Valve Configuration_Floor: yes; Valve Configuration_Wall: no; Général - Connection Set: User to input 'Connection Set' code; Visibilité - External TRV Head: no; Right Valve: no; Left Valve: no; Génie climatique - Débit - Density of Fluid: 1000; Mass Flow Rate_kgPerHr: 23.1287; Mass Flow Rate_kgPerS: 0.00642465; Pressure Drop Value: 0.194434; Pressure Drop_Radiator: 0.0458402; Pressure Drop_Valve: 0.148594; Specific Heat Capacity: 4187; Temp Difference: 10; Valve Flow Factor Kv: 0.6; Flow Rate: 0.0 L/s; Pressure Drop: 45.8 Pa; Electrique - Position 4 8: no; Position 1 5: no; Position 4 5: no; Position M M: yes; Position 1 8: no; Position 8 1: no; valve height: 0.06 m; Connector Flow Height: 0.03 m; Connector Return Height: 0.03 m; Connector Return Dist: 0.295 m; Connector Flow Dist: 0.325 m
202_RADIATEUR GENERIQUE | Type | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1459716 | Equipement de génie climatique | 2021_015 | Autre - Famille et type: Type; Famille: Type; Type: Type; ID du type: Type; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RADIATOR; Exporter au format IFC sous: IfcSpaceHeaterType; Revizto - Architecture: yes; Plumbing: yes; Mechanical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Retour hydraulique,Alimentation hydraulique; Corrected Output: 269; Delta T_MWT Room: 50; Flow Temp: 75; Mean Water Temp: 70; Return Temp: 65; Room Temp: 20; Cotes - Volume: 0.0756711 m3; Surface: 1.40418 m2; Connection Radius: 0.0075 m; Connection Diameter: 0.015 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.2 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.2 m; Angle: 0 deg; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.3.6; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1480591; Nom: Type; Elévation par défaut: 0 m; Note d'identification: 200_CHAUFFAGE; Catégorie: Equipement de génie climatique; Exporter le type au format IFC: 0; Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Sous-projet: Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE; Nom de la famille: 202_RADIATEUR GENERIQUE; Nom du type: Type; Depth: 0.067 m; Height: 2 m; Classification: 0; Length: 0.62 m; _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Offset From Wall: 0.017 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Weight: 4; Water Volume: 0.31; Product Family: Wall Mounted; Heating Element Type: 6; EN442 Output DT50: 269; N_Value: 1.41; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; ROP_SUIVIE DE CHANTIER - Installation ?: no; Matériaux et finitions - Radiator Finish: Jaga - RAL 9016 - Traffic White - 233; Valve Finish: Jaga - RAL 9016 - Traffic White - 233; Construction - Valve Configuration_Floor: yes; Valve Configuration_Wall: no; Général - Connection Set: User to input 'Connection Set' code; Visibilité - External TRV Head: no; Right Valve: no; Left Valve: no; Génie climatique - Débit - Density of Fluid: 1000; Mass Flow Rate_kgPerHr: 23.1287; Mass Flow Rate_kgPerS: 0.00642465; Pressure Drop Value: 0.194434; Pressure Drop_Radiator: 0.0458402; Pressure Drop_Valve: 0.148594; Specific Heat Capacity: 4187; Temp Difference: 10; Valve Flow Factor Kv: 0.6; Flow Rate: 0.0 L/s; Pressure Drop: 45.8 Pa; Electrique - Position 4 8: no; Position 1 5: no; Position 4 5: no; Position M M: yes; Position 1 8: no; Position 8 1: no; valve height: 0.06 m; Connector Flow Height: 0.03 m; Connector Return Height: 0.03 m; Connector Return Dist: 0.295 m; Connector Flow Dist: 0.325 m
202_RADIATEUR GENERIQUE | Type | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1459737 | Equipement de génie climatique | 2021_015 | Autre - Famille et type: Type; Famille: Type; Type: Type; ID du type: Type; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RADIATOR; Exporter au format IFC sous: IfcSpaceHeaterType; Revizto - Architecture: yes; Plumbing: yes; Mechanical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Retour hydraulique,Alimentation hydraulique; Corrected Output: 269; Delta T_MWT Room: 50; Flow Temp: 75; Mean Water Temp: 70; Return Temp: 65; Room Temp: 20; Cotes - Volume: 0.0756711 m3; Surface: 1.40418 m2; Connection Radius: 0.0075 m; Connection Diameter: 0.015 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.2 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.2 m; Angle: 0 deg; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.3.6; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1480591; Nom: Type; Elévation par défaut: 0 m; Note d'identification: 200_CHAUFFAGE; Catégorie: Equipement de génie climatique; Exporter le type au format IFC: 0; Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Sous-projet: Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE; Nom de la famille: 202_RADIATEUR GENERIQUE; Nom du type: Type; Depth: 0.067 m; Height: 2 m; Classification: 0; Length: 0.62 m; _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Offset From Wall: 0.017 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Weight: 4; Water Volume: 0.31; Product Family: Wall Mounted; Heating Element Type: 6; EN442 Output DT50: 269; N_Value: 1.41; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; ROP_SUIVIE DE CHANTIER - Installation ?: no; Matériaux et finitions - Radiator Finish: Jaga - RAL 9016 - Traffic White - 233; Valve Finish: Jaga - RAL 9016 - Traffic White - 233; Construction - Valve Configuration_Floor: yes; Valve Configuration_Wall: no; Général - Connection Set: User to input 'Connection Set' code; Visibilité - External TRV Head: no; Right Valve: no; Left Valve: no; Génie climatique - Débit - Density of Fluid: 1000; Mass Flow Rate_kgPerHr: 23.1287; Mass Flow Rate_kgPerS: 0.00642465; Pressure Drop Value: 0.194434; Pressure Drop_Radiator: 0.0458402; Pressure Drop_Valve: 0.148594; Specific Heat Capacity: 4187; Temp Difference: 10; Valve Flow Factor Kv: 0.6; Flow Rate: 0.0 L/s; Pressure Drop: 45.8 Pa; Electrique - Position 4 8: no; Position 1 5: no; Position 4 5: no; Position M M: yes; Position 1 8: no; Position 8 1: no; valve height: 0.06 m; Connector Flow Height: 0.03 m; Connector Return Height: 0.03 m; Connector Return Dist: 0.295 m; Connector Flow Dist: 0.325 m
202_RADIATEUR GENERIQUE | Type | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1459758 | Equipement de génie climatique | 2021_015 | Autre - Famille et type: Type; Famille: Type; Type: Type; ID du type: Type; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RADIATOR; Exporter au format IFC sous: IfcSpaceHeaterType; Revizto - Architecture: yes; Plumbing: yes; Mechanical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Retour hydraulique,Alimentation hydraulique; Corrected Output: 269; Delta T_MWT Room: 50; Flow Temp: 75; Mean Water Temp: 70; Return Temp: 65; Room Temp: 20; Cotes - Volume: 0.0756711 m3; Surface: 1.40418 m2; Connection Radius: 0.0075 m; Connection Diameter: 0.015 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.2 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.2 m; Angle: 0 deg; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.3.6; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1480591; Nom: Type; Elévation par défaut: 0 m; Note d'identification: 200_CHAUFFAGE; Catégorie: Equipement de génie climatique; Exporter le type au format IFC: 0; Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Sous-projet: Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE; Nom de la famille: 202_RADIATEUR GENERIQUE; Nom du type: Type; Depth: 0.067 m; Height: 2 m; Classification: 0; Length: 0.62 m; _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Offset From Wall: 0.017 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Weight: 4; Water Volume: 0.31; Product Family: Wall Mounted; Heating Element Type: 6; EN442 Output DT50: 269; N_Value: 1.41; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; ROP_SUIVIE DE CHANTIER - Installation ?: no; Matériaux et finitions - Radiator Finish: Jaga - RAL 9016 - Traffic White - 233; Valve Finish: Jaga - RAL 9016 - Traffic White - 233; Construction - Valve Configuration_Floor: yes; Valve Configuration_Wall: no; Général - Connection Set: User to input 'Connection Set' code; Visibilité - External TRV Head: no; Right Valve: no; Left Valve: no; Génie climatique - Débit - Density of Fluid: 1000; Mass Flow Rate_kgPerHr: 23.1287; Mass Flow Rate_kgPerS: 0.00642465; Pressure Drop Value: 0.194434; Pressure Drop_Radiator: 0.0458402; Pressure Drop_Valve: 0.148594; Specific Heat Capacity: 4187; Temp Difference: 10; Valve Flow Factor Kv: 0.6; Flow Rate: 0.0 L/s; Pressure Drop: 45.8 Pa; Electrique - Position 4 8: no; Position 1 5: no; Position 4 5: no; Position M M: yes; Position 1 8: no; Position 8 1: no; valve height: 0.06 m; Connector Flow Height: 0.03 m; Connector Return Height: 0.03 m; Connector Return Dist: 0.295 m; Connector Flow Dist: 0.325 m
202_RADIATEUR GENERIQUE | Type | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1459764 | Equipement de génie climatique | 2021_015 | Autre - Famille et type: Type; Famille: Type; Type: Type; ID du type: Type; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Plumbing: yes; Mechanical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Retour hydraulique,Alimentation hydraulique; Corrected Output: 269; Delta T_MWT Room: 50; Flow Temp: 75; Mean Water Temp: 70; Return Temp: 65; Room Temp: 20; Cotes - Volume: 0.0756711 m3; Surface: 1.40418 m2; Connection Radius: 0.0075 m; Connection Diameter: 0.015 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0 m; Angle: 0 deg; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.3.6; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1480591; Nom: Type; Elévation par défaut: 0 m; Note d'identification: 200_CHAUFFAGE; Catégorie: Equipement de génie climatique; Exporter le type au format IFC: 0; Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Sous-projet: Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE; Nom de la famille: 202_RADIATEUR GENERIQUE; Nom du type: Type; Depth: 0.067 m; Height: 2 m; Classification: 0; Length: 0.62 m; _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Offset From Wall: 0.017 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Weight: 4; Water Volume: 0.31; Product Family: Wall Mounted; Heating Element Type: 6; EN442 Output DT50: 269; N_Value: 1.41; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; ROP_SUIVIE DE CHANTIER - Installation ?: no; Matériaux et finitions - Radiator Finish: Jaga - RAL 9016 - Traffic White - 233; Valve Finish: Jaga - RAL 9016 - Traffic White - 233; Construction - Valve Configuration_Floor: yes; Valve Configuration_Wall: no; Général - Connection Set: User to input 'Connection Set' code; Visibilité - External TRV Head: no; Right Valve: no; Left Valve: no; Génie climatique - Débit - Density of Fluid: 1000; Mass Flow Rate_kgPerHr: 23.1287; Mass Flow Rate_kgPerS: 0.00642465; Pressure Drop Value: 0.194434; Pressure Drop_Radiator: 0.0458402; Pressure Drop_Valve: 0.148594; Specific Heat Capacity: 4187; Temp Difference: 10; Valve Flow Factor Kv: 0.6; Flow Rate: 0.0 L/s; Pressure Drop: 45.8 Pa; Electrique - Position 4 8: no; Position 1 5: no; Position 4 5: no; Position M M: yes; Position 1 8: no; Position 8 1: no; valve height: 0.06 m; Connector Flow Height: 0.03 m; Connector Return Height: 0.03 m; Connector Return Dist: 0.295 m; Connector Flow Dist: 0.325 m
