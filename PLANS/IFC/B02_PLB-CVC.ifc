Properties of the parts of a building model (IFC4), part 8 of 10

# IfcBuildingElementPart (358)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
Canalisation | Standard | Canalisation | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1379209 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 4; Type de système: Eaux Usées; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.0680552 m; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0206544 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit par appareil: 0; Rugosité relative: 0.00111801; Tronçon: 2; Contraintes - Arase inférieure à son extrémité aval: 0.0843722 m; Arase supérieure à son extrémité amont: 0.132632 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0880552 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.0880552 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.128949 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.128949 m; Arase supérieure à son extrémité aval: 0.132632 m; Arase inférieure à son extrémité amont: 0.0843722 m; Elévation de l'axe à son extrémité aval: 0.108502 m; Elévation de l'axe à son extrémité amont: 0.108502 m; Inclinaison: 0.00%; Elévation du milieu: 0.108502 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.108502 m; Élévation centrale de départ: 0.108502 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm; Arase inférieure avec isolant à son extrémité aval: 0.0843722 m; Arase supérieure avec isolant à son extrémité aval: 0.132632 m; Arase inférieure avec isolant à son extrémité amont: 0.0843722 m; Arase supérieure avec isolant à son extrémité amont: 0.132632 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Taille: ø40 mm; Longueur: 0.164362 m
Canalisation | Standard | Canalisation | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1379235 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 4; Type de système: Eaux Usées; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.0680552 m; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.301203 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit par appareil: 0; Rugosité relative: 0.00111801; Tronçon: 2; Contraintes - Arase inférieure à son extrémité aval: 0.0843722 m; Arase supérieure à son extrémité amont: 0.132632 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0880552 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.0880552 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.128949 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.128949 m; Arase supérieure à son extrémité aval: 0.132632 m; Arase inférieure à son extrémité amont: 0.0843722 m; Elévation de l'axe à son extrémité aval: 0.108502 m; Elévation de l'axe à son extrémité amont: 0.108502 m; Inclinaison: 0.00%; Elévation du milieu: 0.108502 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.108502 m; Élévation centrale de départ: 0.108502 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm; Arase inférieure avec isolant à son extrémité aval: 0.0843722 m; Arase supérieure avec isolant à son extrémité aval: 0.132632 m; Arase inférieure avec isolant à son extrémité amont: 0.0843722 m; Arase supérieure avec isolant à son extrémité amont: 0.132632 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Taille: ø40 mm; Longueur: 2.3969 m
Canalisation | Standard | Canalisation | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1379818 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 4; Type de système: Eaux Usées; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.124806 m; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0345142 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit par appareil: 0; Rugosité relative: 0.00111801; Tronçon: 2; Contraintes - Arase inférieure à son extrémité aval: 0.144521 m; Arase supérieure à son extrémité amont: 0.422087 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.144806 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.418638 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.147971 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.421802 m; Arase supérieure à son extrémité aval: 0.148256 m; Arase inférieure à son extrémité amont: 0.418353 m; Elévation de l'axe à son extrémité aval: 0.146388 m; Elévation de l'axe à son extrémité amont: 0.42022 m; Inclinaison: 1288.41%; Elévation du milieu: 0.146388 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.42022 m; Élévation centrale de départ: 0.146388 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm; Arase inférieure avec isolant à son extrémité aval: 0.144521 m; Arase supérieure avec isolant à son extrémité aval: 0.148256 m; Arase inférieure avec isolant à son extrémité amont: 0.418353 m; Arase supérieure avec isolant à son extrémité amont: 0.422087 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Taille: ø40 mm; Longueur: 0.274655 m
Canalisation | Standard | Canalisation | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1379929 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.12494 m; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0344983 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit par appareil: 0; Rugosité relative: 0.00111801; Tronçon: 22; Contraintes - Arase inférieure à son extrémité aval: 0.144653 m; Arase supérieure à son extrémité amont: 0.422104 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.14494 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.418637 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.14812 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.421817 m; Arase supérieure à son extrémité aval: 0.148406 m; Arase inférieure à son extrémité amont: 0.418351 m; Elévation de l'axe à son extrémité aval: 0.14653 m; Elévation de l'axe à son extrémité amont: 0.420227 m; Inclinaison: 1282.04%; Elévation du milieu: 0.14653 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.420227 m; Élévation centrale de départ: 0.14653 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm; Arase inférieure avec isolant à son extrémité aval: 0.144653 m; Arase supérieure avec isolant à son extrémité aval: 0.148406 m; Arase inférieure avec isolant à son extrémité amont: 0.418351 m; Arase supérieure avec isolant à son extrémité amont: 0.422104 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Taille: ø40 mm; Longueur: 0.274529 m
Canalisation | Standard | Canalisation | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1529357 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.48059 m; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00630514 m2; Phase de construction - Phase de création: Existant; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit par appareil: 0; Rugosité relative: 0.00111801; Tronçon: 13; Contraintes - Arase inférieure à son extrémité aval: 0.496907 m; Arase supérieure à son extrémité amont: 0.545167 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.50059 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.50059 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.541484 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.541484 m; Arase supérieure à son extrémité aval: 0.545167 m; Arase inférieure à son extrémité amont: 0.496907 m; Elévation de l'axe à son extrémité aval: 0.521037 m; Elévation de l'axe à son extrémité amont: 0.521037 m; Inclinaison: 0.00%; Elévation du milieu: 0.521037 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.521037 m; Élévation centrale de départ: 0.521037 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm; Arase inférieure avec isolant à son extrémité aval: 0.496907 m; Arase supérieure avec isolant à son extrémité aval: 0.545167 m; Arase inférieure avec isolant à son extrémité amont: 0.496907 m; Arase supérieure avec isolant à son extrémité amont: 0.545167 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Taille: ø40 mm; Longueur: 0.0501747 m
3 x Ligne d'axe | Category | Ligne d'axe | N0
Raccords de canalisation | Category | Raccords de canalisation | N0
Coude - Générique | Family | Coude - Générique | N0
Coude - Générique | Standard | Coude - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1353935 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.015909 m; Rayon du centre: 0.015909 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.00001268 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 90 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.1 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
3 x Coude - Générique | Instance | Coude - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 733349 | Raccords de canalisation | Famille : Raccords de canalisation : Coude - Générique | Autre - Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Coude - Générique | Standard | Coude - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1353937 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.015909 m; Rayon du centre: 0.015909 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.00001268 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 90 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.1 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Coude - Générique | Standard | Coude - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1354160 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.015909 m; Rayon du centre: 0.015909 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.00001268 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 90 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.7 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Coude - Générique | Standard | Coude - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1379833 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.0379881 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 4; Type de système: Eaux Usées; Cotes - Volume: 0.000109352 m3; Taille: ø40 mm-ø40 mm; Taille maximale: 0.04 m; Taille minimale: 0.04 m; Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 90.018 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.108502 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm-ø40 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Coude - Générique | Instance | Coude - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1379835 | Raccords de canalisation | Famille : Raccords de canalisation : Coude - Générique | Autre - Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Coude - Générique | Standard | Coude - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1528544 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.0380009 m; Paramètres IFC - Exporter au format IFC: 0; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 4; Type de système: Eaux Usées; Cotes - Volume: 0.000109365 m3; Taille: ø40 mm-ø40 mm; Taille maximale: 0.04 m; Taille minimale: 0.04 m; Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 89.9986 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.108502 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm-ø40 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Coude - Générique | Instance | Coude - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1528546 | Raccords de canalisation | Famille : Raccords de canalisation : Coude - Générique | Autre - Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Coude - Générique | Standard | Coude - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1528706 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.038 m; Paramètres IFC - Exporter au format IFC: 0; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Cotes - Volume: 0.000109364 m3; Taille: ø40 mm-ø40 mm; Taille maximale: 0.04 m; Taille minimale: 0.04 m; Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 90 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.108645 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm-ø40 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Coude - Générique | Instance | Coude - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1379222 | Raccords de canalisation | Famille : Raccords de canalisation : Coude - Générique | Autre - Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Coude - Générique | Standard | Coude - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1529473 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.0379967 m; Paramètres IFC - Exporter au format IFC: 0; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Cotes - Volume: 0.000109361 m3; Taille: ø40 mm-ø40 mm; Taille maximale: 0.04 m; Taille minimale: 0.04 m; Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 90.005 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.0883965 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm-ø40 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Coude - Générique | Instance | Coude - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1529475 | Raccords de canalisation | Famille : Raccords de canalisation : Coude - Générique | Autre - Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Coude - Générique | Standard | Coude - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1529478 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.0380012 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Cotes - Volume: 0.000109365 m3; Taille: ø40 mm-ø40 mm; Taille maximale: 0.04 m; Taille minimale: 0.04 m; Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 89.9982 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.521037 m; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm-ø40 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Coude - Générique | Instance | Coude - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1529465 | Raccords de canalisation | Famille : Raccords de canalisation : Coude - Générique | Autre - Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Té - Générique | Family | Té - Générique | N0
Té - Générique | Standard | Té - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1354164 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.01065 m; Libellé de centre à extrémité: 0.025 m; Angle 1: 90 deg; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000235024 m3; Taille: ø15 mm-ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.0213 m; Taille de la coche: 0.00852 m; Centre à extrémité: 0.025 m; Angle: 90 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.7 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642936; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Té - Générique; Nom de la famille: Té - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Tee; Nom de la table de consultation: Tee - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Té - Générique | Instance | Té - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 642936 | Raccords de canalisation | Famille : Raccords de canalisation : Té - Générique | Autre - Nom de la famille: Té - Générique; Nom de la table de consultation: Tee - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Tee
Té - Générique | Standard | Té - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1378192 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.0167 m; Libellé de centre à extrémité: 0.038 m; Angle 1: 90 deg; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000874588 m3; Taille: ø25 mm-ø25 mm-ø25 mm; Taille maximale: 0.025 m; Taille minimale: 0.025 m; Rayon nominal: 0.0125 m; Diamètre nominal: 0.025 m; Diamètre extérieur du raccord: 0.0334 m; Taille de la coche: 0.01336 m; Centre à extrémité: 0.038 m; Angle: 90 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.1 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642936; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Té - Générique; Nom de la famille: Té - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Tee; Nom de la table de consultation: Tee - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm-ø25 mm-ø25 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Té - Générique | Instance | Té - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1378196 | Raccords de canalisation | Famille : Raccords de canalisation : Té - Générique | Autre - Nom de la famille: Té - Générique; Nom de la table de consultation: Tee - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Tee
RACCORD REDUCTEUR 15-10 | Family | RACCORD REDUCTEUR 15-10 | N0
RACCORD REDUCTEUR 15-10 | Type | RACCORD REDUCTEUR 15-10 | N0
RACCORD REDUCTEUR 15-10 | RACCORD REDUCTEUR 15-10 | RACCORD REDUCTEUR 15-10 | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1354250 | Raccords de canalisation | 2021_015 | Autre - Famille et type: RACCORD REDUCTEUR 15-10; Famille: RACCORD REDUCTEUR 15-10; Type: RACCORD REDUCTEUR 15-10; ID du type: RACCORD REDUCTEUR 15-10; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: TRANSITION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.00000102309 m3; Surface: 0.000781767 m2; Taille: ø15 mm-ø10 mm; Taille maximale: 0.015 m; Taille minimale: 0.01 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.731 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1350737; Nom: RACCORD REDUCTEUR 15-10; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : RACCORD REDUCTEUR 15-10; Nom de la famille: RACCORD REDUCTEUR 15-10; Nom du type: RACCORD REDUCTEUR 15-10; Génie climatique - Débit - Perte de pression: 0.0 Pa; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø10 mm; Graphismes - Utiliser l'échelle d'annotations: yes
2 x RACCORD REDUCTEUR 15-10 | Instance | RACCORD REDUCTEUR 15-10 | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1350737 | Raccords de canalisation | Famille : Raccords de canalisation : RACCORD REDUCTEUR 15-10 | Autre - Nom de la famille: RACCORD REDUCTEUR 15-10; Données d'identification - Nom du type: RACCORD REDUCTEUR 15-10; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
RACCORD REDUCTEUR 15-10 | RACCORD REDUCTEUR 15-10 | RACCORD REDUCTEUR 15-10 | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1354263 | Raccords de canalisation | 2021_015 | Autre - Famille et type: RACCORD REDUCTEUR 15-10; Famille: RACCORD REDUCTEUR 15-10; Type: RACCORD REDUCTEUR 15-10; ID du type: RACCORD REDUCTEUR 15-10; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: TRANSITION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.00000102309 m3; Surface: 0.000781767 m2; Taille: ø15 mm-ø10 mm; Taille maximale: 0.015 m; Taille minimale: 0.01 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.669 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1350737; Nom: RACCORD REDUCTEUR 15-10; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : RACCORD REDUCTEUR 15-10; Nom de la famille: RACCORD REDUCTEUR 15-10; Nom du type: RACCORD REDUCTEUR 15-10; Génie climatique - Débit - Perte de pression: 0.0 Pa; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø10 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Transformation - Générique | Family | Transformation - Générique | N0
Transformation - Générique | Standard | Transformation - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1378201 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord 1: 0.0167 m; Rayon extérieur du raccord 2: 0.012709 m; Diamètre nominal max. 12: 0.025 m; Décalage de la largeur: 3.04801 m; Décalage de la hauteur: 3.048 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000346997 m3; Surface: 0.00372677 m2; Taille: ø25 mm-ø15 mm; Longueur: 0.051 m; Taille maximale: 0.025 m; Taille minimale: 0.015 m; Hauteur de décalage: 12.5000 mm; Largeur de décalage: 12.5085 mm; Rayon nominal 1: 0.0125 m; Diamètre nominal 1: 0.025 m; Diamètre extérieur du raccord 1: 0.0334 m; Taille de la coche 1: 0.01336 m; Rayon nominal 2: 0.0075 m; Diamètre nominal 2: 0.015 m; Diamètre extérieur du raccord 2: 0.025418 m; Taille de la coche 2: 0.0101672 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.1 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 643819; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Transformation - Générique; Nom de la famille: Transformation - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser; Nom de la table de consultation: Transition - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Transformation - Générique | Instance | Transformation - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1378203 | Raccords de canalisation | Famille : Raccords de canalisation : Transformation - Générique | Autre - Nom de la famille: Transformation - Générique; Nom de la table de consultation: Transition - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser
Transformation - Générique | Standard | Transformation - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1378950 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord 1: 0.05715 m; Rayon extérieur du raccord 2: 0.02415 m; Diamètre nominal max. 12: 0.1 m; Décalage de la largeur: 3.048 m; Décalage de la hauteur: 3.04767 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Cotes - Volume: 0.000558212 m3; Surface: 0.0253404 m2; Taille: ø100 mm-ø40 mm; Longueur: 0.102 m; Taille maximale: 0.1 m; Taille minimale: 0.04 m; Hauteur de décalage: 49.6651 mm; Largeur de décalage: 50.0033 mm; Rayon nominal 1: 0.05 m; Diamètre nominal 1: 0.1 m; Diamètre extérieur du raccord 1: 0.1143 m; Taille de la coche 1: 0.04572 m; Rayon nominal 2: 0.02 m; Diamètre nominal 2: 0.04 m; Diamètre extérieur du raccord 2: 0.0483 m; Taille de la coche 2: 0.01932 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.0887314 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 643819; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Transformation - Générique; Nom de la famille: Transformation - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser; Nom de la table de consultation: Transition - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø100 mm-ø40 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Transformation - Générique | Instance | Transformation - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1378724 | Raccords de canalisation | Famille : Raccords de canalisation : Transformation - Générique | Autre - Nom de la famille: Transformation - Générique; Nom de la table de consultation: Transition - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser
Transformation - Générique | Standard | Transformation - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1379948 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord 1: 0.05715 m; Rayon extérieur du raccord 2: 0.02415 m; Diamètre nominal max. 12: 0.1 m; Décalage de la largeur: 3.04797 m; Décalage de la hauteur: 3.05567 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Cotes - Volume: 0.000558212 m3; Surface: 0.0254768 m2; Taille: ø100 mm-ø40 mm; Longueur: 0.102 m; Taille maximale: 0.1 m; Taille minimale: 0.04 m; Hauteur de décalage: 57.6661 mm; Largeur de décalage: 49.9749 mm; Rayon nominal 1: 0.05 m; Diamètre nominal 1: 0.1 m; Diamètre extérieur du raccord 1: 0.1143 m; Taille de la coche 1: 0.04572 m; Rayon nominal 2: 0.02 m; Diamètre nominal 2: 0.04 m; Diamètre extérieur du raccord 2: 0.0483 m; Taille de la coche 2: 0.01932 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.100979 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 643819; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Transformation - Générique; Nom de la famille: Transformation - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser; Nom de la table de consultation: Transition - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø100 mm-ø40 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Transformation - Générique | Instance | Transformation - Générique | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1379950 | Raccords de canalisation | Famille : Raccords de canalisation : Transformation - Générique | Autre - Nom de la famille: Transformation - Générique; Nom de la table de consultation: Transition - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser
Canalisation souple | Category | Canalisation souple | N0
Canalisation souple arrondie | Family | Canalisation souple arrondie | N0
Souple - Circulaire | Type | Souple - Circulaire | N0
Canalisation souple arrondie | Souple - Circulaire | Canalisation souple arrondie | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1354281 | Canalisation souple | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Diamètre: 0.01 m; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142445; Nom: Souple - Circulaire; Catégorie: Canalisation souple; Exporter le type au format IFC: 0; Sous-projet: Types de canalisations souples; Nom de la famille: Canalisation souple arrondie; Nom du type: Souple - Circulaire; Rugosité: 0.00004572 m; Type de jonction préférée: 1; Union: Standard; Transition: Standard; Té: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.004572; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 5; Contraintes - Élévation centrale de départ: 0.663 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø10 mm; Cotes - Epaisseur de paroi: 0 m; Diamètre extérieur: 0.01 m; Diamètre intérieur: 0.01 m; Longueur: 0.184249 m; Graphismes - Modèle de gaine flexible: 0
Canalisation souple arrondie | Souple - Circulaire | Canalisation souple arrondie | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1354284 | Canalisation souple | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Diamètre: 0.01 m; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142445; Nom: Souple - Circulaire; Catégorie: Canalisation souple; Exporter le type au format IFC: 0; Sous-projet: Types de canalisations souples; Nom de la famille: Canalisation souple arrondie; Nom du type: Souple - Circulaire; Rugosité: 0.00004572 m; Type de jonction préférée: 1; Union: Standard; Transition: Standard; Té: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.004572; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 45; Contraintes - Élévation centrale de départ: 0.931105 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø10 mm; Cotes - Epaisseur de paroi: 0 m; Diamètre extérieur: 0.01 m; Diamètre intérieur: 0.01 m; Longueur: 0.202492 m; Graphismes - Modèle de gaine flexible: 0
Canalisation souple arrondie | Souple - Circulaire | Canalisation souple arrondie | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1380046 | Canalisation souple | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau chaude sanitaire; Nom du système: Eau Chaude Sanitaire 1; Type de système: Eau Chaude Sanitaire; Diamètre: 0.01 m; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142445; Nom: Souple - Circulaire; Catégorie: Canalisation souple; Exporter le type au format IFC: 0; Sous-projet: Types de canalisations souples; Nom de la famille: Canalisation souple arrondie; Nom du type: Souple - Circulaire; Rugosité: 0.00004572 m; Type de jonction préférée: 1; Union: Standard; Transition: Standard; Té: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.004572; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Contraintes - Élévation centrale de départ: 0.490536 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø10 mm; Cotes - Epaisseur de paroi: 0 m; Diamètre extérieur: 0.01 m; Diamètre intérieur: 0.01 m; Longueur: 0.447539 m; Graphismes - Modèle de gaine flexible: 0
Accessoire de canalisation | Category | Accessoire de canalisation | N0
STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | Family | STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | N0
CHICAGO Palanca Azul H-H | Type | CHICAGO Palanca Azul H-H | N0
STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | CHICAGO Palanca Azul H-H | STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1354442 | Accessoire de canalisation | 2021_015 | Autre - Famille et type: CHICAGO Palanca Azul H-H; Famille: CHICAGO Palanca Azul H-H; Type: CHICAGO Palanca Azul H-H; ID du type: CHICAGO Palanca Azul H-H; CRP: 10004; C1: 4; C2: 1; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FAUCET; Exporter au format IFC sous: IfcValveType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000392733 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; D2: 0.0135 m; DN: 0.015 m; RN: 0.0075 m; DN (pulgadas): 1/2''; A: 0.046 m; B: 0.095 m; h: 0.046 m; h1: 0.0328 m; D1: 0.031 m; R1: 0.0155 m; A1: 0.01156 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.551329 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 921729; Nom: CHICAGO Palanca Azul H-H; Elévation par défaut: 0 m; Catégorie: Accessoire de canalisation; Exporter le type au format IFC: 0; Modèle: Válvula de esfera roscar CHICAGO palanca H-H; Fabricant: STH STANDARD HIDRAULICA; URL: http://www.standardhidraulica.com/; Description: Válvula de esfera roscar CHICAGO palanca H-H. Adecuada para agua fría, ACS y aire. Zonas en contacto con el fluido, no cromado. Producto básico y funcional; Titre OmniClass: Adjusting/Controlling Valves for Liquid Services; Numéro OmniClass: 23.65.55.14.17; Sous-projet: Famille : Accessoire de canalisation : STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom de la famille: STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom du type: CHICAGO Palanca Azul H-H; Type: Type prédéfini d'IFC: CHECK; Exporter le type au format IFC sous: IfcValveType; IfcExportAs: IfcValveType; IfcExportType: CHECK; Coefficient K: 0; Normativa UNE (accesorios): UNE-EN 12.164-12.165; BIMETRICAL Category: Valve; Versión Familia: 1.0; Versión Revit: Revit 2016 - Español; Fecha de Revisión: 09/2017; Creado por: BIMETRICAL; BIMETRICAL: http://www.bimetrical.com/; Nombre_Lookup_Cotas: STH Valvula Esfera Palanca H-H CHICAGO - Cotas; PN: PN 25; Temperatura: -10 ºC a 110 ºC; Nombre_Lookup_Referencia: STH Valvula Esfera Palanca H-H CHICAGO - Referencia; Material cuerpo: STH_Latón Acabado Niquelado; Material palanca: STH_Aluminio; G: 0.008 m; Color palanca: STH_Palanca Azul; G1: 0.0073 m; Palanca Azul: yes; Palanca Roja: no; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes; Données d'identification - Referencia Producto: 34501; Código: 34501
STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | Instance | STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 922235 | Accessoire de canalisation | Famille : Accessoire de canalisation : STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | Autre - Nom de la famille: STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nombre_Lookup_Cotas: STH Valvula Esfera Palanca H-H CHICAGO - Cotas; Nombre_Lookup_Referencia: STH Valvula Esfera Palanca H-H CHICAGO - Referencia; Données d'identification - Modèle: Válvula de esfera roscar CHICAGO palanca H-H; Fabricant: STH STANDARD HIDRAULICA; URL: http://www.standardhidraulica.com/; Description: Válvula de esfera roscar CHICAGO palanca H-H. Adecuada para agua fría, ACS y aire. Zonas en contacto con el fluido, no cromado. Producto básico y funcional; Titre OmniClass: Adjusting/Controlling Valves for Liquid Services; Numéro OmniClass: 23.65.55.14.17; Nom du type: CHICAGO Palanca Azul H-H; Normativa UNE (accesorios): UNE-EN 12.164-12.165; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: CHECK; Exporter le type au format IFC sous: IfcValveType; IfcExportAs: IfcValveType; IfcExportType: CHECK; BIMETRICAL Category: Valve; Versión Familia: 1.0; Versión Revit: Revit 2016 - Español; Fecha de Revisión: 09/2017; Creado por: BIMETRICAL; BIMETRICAL: http://www.bimetrical.com/; Génie climatique - Coefficient K: 0; Données - PN: PN 25; Temperatura: -10 ºC a 110 ºC; Palanca Azul: yes; Palanca Roja: no; Matériaux et finitions - Material cuerpo: STH_Latón Acabado Niquelado; Material palanca: STH_Aluminio; Color palanca: STH_Palanca Azul; Cotes - G: 0.008 m; G1: 0.0073 m
Equipement de génie climatique | Category | Equipement de génie climatique | N0
201_PAC GENERIQUE | Family | 201_PAC GENERIQUE | N0
201_PAC GENERIQUE | Type | 201_PAC GENERIQUE | N0
