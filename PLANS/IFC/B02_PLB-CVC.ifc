Properties of the parts of a building model (IFC4), part 6 of 10

# IfcBuildingElementPart (358)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
202_RADIATEUR GENERIQUE | Type | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1459773 | Equipement de génie climatique | 2021_015 | Autre - Famille et type: Type; Famille: Type; Type: Type; ID du type: Type; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Plumbing: yes; Mechanical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Retour hydraulique,Alimentation hydraulique; Corrected Output: 269; Delta T_MWT Room: 50; Flow Temp: 75; Mean Water Temp: 70; Return Temp: 65; Room Temp: 20; Cotes - Volume: 0.0756711 m3; Surface: 1.40418 m2; Connection Radius: 0.0075 m; Connection Diameter: 0.015 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0 m; Angle: 0 deg; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.3.6; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1480591; Nom: Type; Elévation par défaut: 0 m; Note d'identification: 200_CHAUFFAGE; Catégorie: Equipement de génie climatique; Exporter le type au format IFC: 0; Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Sous-projet: Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE; Nom de la famille: 202_RADIATEUR GENERIQUE; Nom du type: Type; Depth: 0.067 m; Height: 2 m; Classification: 0; Length: 0.62 m; _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Offset From Wall: 0.017 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Weight: 4; Water Volume: 0.31; Product Family: Wall Mounted; Heating Element Type: 6; EN442 Output DT50: 269; N_Value: 1.41; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; ROP_SUIVIE DE CHANTIER - Installation ?: no; Matériaux et finitions - Radiator Finish: Jaga - RAL 9016 - Traffic White - 233; Valve Finish: Jaga - RAL 9016 - Traffic White - 233; Construction - Valve Configuration_Floor: yes; Valve Configuration_Wall: no; Général - Connection Set: User to input 'Connection Set' code; Visibilité - External TRV Head: no; Right Valve: no; Left Valve: no; Génie climatique - Débit - Density of Fluid: 1000; Mass Flow Rate_kgPerHr: 23.1287; Mass Flow Rate_kgPerS: 0.00642465; Pressure Drop Value: 0.194434; Pressure Drop_Radiator: 0.0458402; Pressure Drop_Valve: 0.148594; Specific Heat Capacity: 4187; Temp Difference: 10; Valve Flow Factor Kv: 0.6; Flow Rate: 0.0 L/s; Pressure Drop: 45.8 Pa; Electrique - Position 4 8: no; Position 1 5: no; Position 4 5: no; Position M M: yes; Position 1 8: no; Position 8 1: no; valve height: 0.06 m; Connector Flow Height: 0.03 m; Connector Return Height: 0.03 m; Connector Return Dist: 0.295 m; Connector Flow Dist: 0.325 m
202_RADIATEUR GENERIQUE | Type | 202_RADIATEUR GENERIQUE | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1459815 | Equipement de génie climatique | 2021_015 | Autre - Famille et type: Type; Famille: Type; Type: Type; ID du type: Type; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Plumbing: yes; Mechanical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Retour hydraulique,Alimentation hydraulique; Corrected Output: 269; Delta T_MWT Room: 50; Flow Temp: 75; Mean Water Temp: 70; Return Temp: 65; Room Temp: 20; Cotes - Volume: 0.0756711 m3; Surface: 1.40418 m2; Connection Radius: 0.0075 m; Connection Diameter: 0.015 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0 m; Angle: 0 deg; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.3.6; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1480591; Nom: Type; Elévation par défaut: 0 m; Note d'identification: 200_CHAUFFAGE; Catégorie: Equipement de génie climatique; Exporter le type au format IFC: 0; Titre OmniClass: Radiators; Numéro OmniClass: 23.75.70.17.11; Sous-projet: Famille : Equipement de génie climatique : 202_RADIATEUR GENERIQUE; Nom de la famille: 202_RADIATEUR GENERIQUE; Nom du type: Type; Depth: 0.067 m; Height: 2 m; Classification: 0; Length: 0.62 m; _BIMspec_GUID: 0; _created by: Connor Laing; _current revision: 1; _distributed by: www.bimstore.co.uk; Offset From Wall: 0.017 m; d: 0.0265 m; Clearance Below: 0.1 m; Clearance Above: 0.1 m; Weight: 4; Water Volume: 0.31; Product Family: Wall Mounted; Heating Element Type: 6; EN442 Output DT50: 269; N_Value: 1.41; front array: 10; Tube thickness: 0.064 m; grille array: 41; grille length: 0.033 m; Valve Offset: 0 m; Radiator Depth: 0.053 m; grille dist: 0.57 m; ROP_SUIVIE DE CHANTIER - Installation ?: no; Matériaux et finitions - Radiator Finish: Jaga - RAL 9016 - Traffic White - 233; Valve Finish: Jaga - RAL 9016 - Traffic White - 233; Construction - Valve Configuration_Floor: yes; Valve Configuration_Wall: no; Général - Connection Set: User to input 'Connection Set' code; Visibilité - External TRV Head: no; Right Valve: no; Left Valve: no; Génie climatique - Débit - Density of Fluid: 1000; Mass Flow Rate_kgPerHr: 23.1287; Mass Flow Rate_kgPerS: 0.00642465; Pressure Drop Value: 0.194434; Pressure Drop_Radiator: 0.0458402; Pressure Drop_Valve: 0.148594; Specific Heat Capacity: 4187; Temp Difference: 10; Valve Flow Factor Kv: 0.6; Flow Rate: 0.0 L/s; Pressure Drop: 45.8 Pa; Electrique - Position 4 8: no; Position 1 5: no; Position 4 5: no; Position M M: yes; Position 1 8: no; Position 8 1: no; valve height: 0.06 m; Connector Flow Height: 0.03 m; Connector Return Height: 0.03 m; Connector Return Dist: 0.295 m; Connector Flow Dist: 0.325 m
Bouche d'aération | Category | Bouche d'aération | N0 FINI
204_BOUCHE VMC | Family | 204_BOUCHE VMC | N0 FINI
125 | Type | 125 | N0 FINI
204_BOUCHE VMC | 125 | 204_BOUCHE VMC | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1494174 | Bouche d'aération | 2021_015 | Autre - Famille et type: 125; Famille: 125; Type: 125; ID du type: 125; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DIFFUSER; Exporter au format IFC sous: IfcAirTerminalType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 1; Type de système: Reprise; SOUFFLAGE sans déflecteur: yes; SOUFFLAGE avec déflecteur: no; Cotes - Volume: 0.00128786 m3; Surface: 0.329413 m2; Taille: ø125; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Hôte: Modèle Revit lié : B02_ARC.rvt; Élévation par rapport au niveau: 2.5 m; Niveau de nomenclature: N0 FINI; Type de Revit - Id: 1493583; Nom: 125; Elévation par défaut: 1 m; Catégorie: Bouche d'aération; Exporter le type au format IFC: 0; Modèle: AUREA 80; Fabricant: ANJOS Ventilation; URL: https://www.anjos-ventilation.com/; Description: Bouche destinée à l'insufflation dans les logements et les locaux tertiaires; Titre OmniClass: Terminals for Air; Numéro OmniClass: 23.75.70.21; Description de l'assemblage: Terminal & Package Units; Code d'assemblage: D3050; Sous-projet: Famille : Bouche d'aération : 204_BOUCHE VMC; Nom de la famille: 204_BOUCHE VMC; Nom du type: 125; Product data url: https://www.bimobject.com/anjos_ventilation/product/aurea; Commentaires du type: Qv 15; Débit max.: 30.0 m³/h; Débit min.: 30.0 m³/h; Flux: 30.0 m³/h; DN: 0.125 m; _Table: ANJOS-aurea; Distance: 0.029 m; Génie climatique - Débit - Débit: 0.0 m³/h; Trajectoire critique: no; Perte de charge: 0.0 Pa; Vitesse écoulement: 0.0 m/s; Revizto - Mechanical: yes; Données - Niveau de puissance acoustique (dB(A)): 0
204_BOUCHE VMC | Instance | 204_BOUCHE VMC | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1493583 | Bouche d'aération | Famille : Bouche d'aération : 204_BOUCHE VMC | Autre - Nom de la famille: 204_BOUCHE VMC; _Table: ANJOS-aurea; Distance: 0.029 m; Données d'identification - Modèle: AUREA 80; Fabricant: ANJOS Ventilation; URL: https://www.anjos-ventilation.com/; Description: Bouche destinée à l'insufflation dans les logements et les locaux tertiaires; Titre OmniClass: Terminals for Air; Numéro OmniClass: 23.75.70.21; Description de l'assemblage: Terminal & Package Units; Code d'assemblage: D3050; Nom du type: 125; Product data url: https://www.bimobject.com/anjos_ventilation/product/aurea; Commentaires du type: Qv 15; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - DN: 0.125 m; Génie climatique - Débit - Débit max.: 30.0 m³/h; Débit min.: 30.0 m³/h; Flux: 30.0 m³/h
80 | Type | 80 | N0 FINI
204_BOUCHE VMC | 80 | 204_BOUCHE VMC | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1494644 | Bouche d'aération | 2021_015 | Autre - Famille et type: 80; Famille: 80; Type: 80; ID du type: 80; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DIFFUSER; Exporter au format IFC sous: IfcAirTerminal; Phase de création - Catégorie: Phases; Numéro de séquence: 2; Nom: Nouvelle construction; Sous-projet: Paramètres des phases; Id: 86961; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; SOUFFLAGE sans déflecteur: yes; SOUFFLAGE avec déflecteur: no; Cotes - Volume: 0.000412892 m3; Surface: 0.329413 m2; Taille: ø125; Phase de construction - Phase de création: Nouvelle construction; Contraintes - Niveau: N0 FINI; Hôte: Modèle Revit lié : B02_ARC.rvt; Élévation par rapport au niveau: 2.5 m; Niveau de nomenclature: N0 FINI; Type de Revit - Id: 1493581; Nom: 80; Elévation par défaut: 1 m; Catégorie: Bouche d'aération; Exporter le type au format IFC: 0; Modèle: AUREA 80; Fabricant: ANJOS Ventilation; URL: https://www.anjos-ventilation.com/; Description: Bouche destinée à l'insufflation dans les logements et les locaux tertiaires; Titre OmniClass: Terminals for Air; Numéro OmniClass: 23.75.70.21; Description de l'assemblage: Terminal & Package Units; Code d'assemblage: D3050; Sous-projet: Famille : Bouche d'aération : 204_BOUCHE VMC; Nom de la famille: 204_BOUCHE VMC; Nom du type: 80; Product data url: https://www.bimobject.com/anjos_ventilation/product/aurea; Commentaires du type: Qv 15; Débit max.: 30.0 m³/h; Débit min.: 30.0 m³/h; Flux: 30.0 m³/h; DN: 0.08 m; _Table: ANJOS-aurea; Distance: 0.0285 m; Génie climatique - Débit - Débit: 0.0 m³/h; Perte de charge: 8.0 Pa; Vitesse écoulement: 4.2 m/s; Revizto - Mechanical: yes; Données - Niveau de puissance acoustique (dB(A)): 23
3 x 204_BOUCHE VMC | Instance | 204_BOUCHE VMC | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1493581 | Bouche d'aération | Famille : Bouche d'aération : 204_BOUCHE VMC | Autre - Nom de la famille: 204_BOUCHE VMC; _Table: ANJOS-aurea; Distance: 0.0285 m; Données d'identification - Modèle: AUREA 80; Fabricant: ANJOS Ventilation; URL: https://www.anjos-ventilation.com/; Description: Bouche destinée à l'insufflation dans les logements et les locaux tertiaires; Titre OmniClass: Terminals for Air; Numéro OmniClass: 23.75.70.21; Description de l'assemblage: Terminal & Package Units; Code d'assemblage: D3050; Nom du type: 80; Product data url: https://www.bimobject.com/anjos_ventilation/product/aurea; Commentaires du type: Qv 15; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - DN: 0.08 m; Génie climatique - Débit - Débit max.: 30.0 m³/h; Débit min.: 30.0 m³/h; Flux: 30.0 m³/h
204_BOUCHE VMC | 80 | 204_BOUCHE VMC | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1494891 | Bouche d'aération | 2021_015 | Autre - Famille et type: 80; Famille: 80; Type: 80; ID du type: 80; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DIFFUSER; Exporter au format IFC sous: IfcAirTerminal; Phase de création - Catégorie: Phases; Numéro de séquence: 2; Nom: Nouvelle construction; Sous-projet: Paramètres des phases; Id: 86961; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; SOUFFLAGE sans déflecteur: yes; SOUFFLAGE avec déflecteur: no; Cotes - Volume: 0.000412892 m3; Surface: 0.329413 m2; Taille: ø125; Phase de construction - Phase de création: Nouvelle construction; Contraintes - Niveau: N0 FINI; Hôte: Modèle Revit lié : B02_ARC.rvt; Élévation par rapport au niveau: 2.5 m; Niveau de nomenclature: N0 FINI; Type de Revit - Id: 1493581; Nom: 80; Elévation par défaut: 1 m; Catégorie: Bouche d'aération; Exporter le type au format IFC: 0; Modèle: AUREA 80; Fabricant: ANJOS Ventilation; URL: https://www.anjos-ventilation.com/; Description: Bouche destinée à l'insufflation dans les logements et les locaux tertiaires; Titre OmniClass: Terminals for Air; Numéro OmniClass: 23.75.70.21; Description de l'assemblage: Terminal & Package Units; Code d'assemblage: D3050; Sous-projet: Famille : Bouche d'aération : 204_BOUCHE VMC; Nom de la famille: 204_BOUCHE VMC; Nom du type: 80; Product data url: https://www.bimobject.com/anjos_ventilation/product/aurea; Commentaires du type: Qv 15; Débit max.: 30.0 m³/h; Débit min.: 30.0 m³/h; Flux: 30.0 m³/h; DN: 0.08 m; _Table: ANJOS-aurea; Distance: 0.0285 m; Génie climatique - Débit - Débit: 0.0 m³/h; Perte de charge: 8.0 Pa; Vitesse écoulement: 4.2 m/s; Revizto - Mechanical: yes; Données - Niveau de puissance acoustique (dB(A)): 23
204_BOUCHE VMC | 80 | 204_BOUCHE VMC | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1494913 | Bouche d'aération | 2021_015 | Autre - Famille et type: 80; Famille: 80; Type: 80; ID du type: 80; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DIFFUSER; Exporter au format IFC sous: IfcAirTerminal; Phase de création - Catégorie: Phases; Numéro de séquence: 2; Nom: Nouvelle construction; Sous-projet: Paramètres des phases; Id: 86961; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; SOUFFLAGE sans déflecteur: yes; SOUFFLAGE avec déflecteur: no; Cotes - Volume: 0.000412892 m3; Surface: 0.329413 m2; Taille: ø125; Phase de construction - Phase de création: Nouvelle construction; Contraintes - Niveau: N0 FINI; Hôte: Modèle Revit lié : B02_ARC.rvt; Élévation par rapport au niveau: 2.5 m; Niveau de nomenclature: N0 FINI; Type de Revit - Id: 1493581; Nom: 80; Elévation par défaut: 1 m; Catégorie: Bouche d'aération; Exporter le type au format IFC: 0; Modèle: AUREA 80; Fabricant: ANJOS Ventilation; URL: https://www.anjos-ventilation.com/; Description: Bouche destinée à l'insufflation dans les logements et les locaux tertiaires; Titre OmniClass: Terminals for Air; Numéro OmniClass: 23.75.70.21; Description de l'assemblage: Terminal & Package Units; Code d'assemblage: D3050; Sous-projet: Famille : Bouche d'aération : 204_BOUCHE VMC; Nom de la famille: 204_BOUCHE VMC; Nom du type: 80; Product data url: https://www.bimobject.com/anjos_ventilation/product/aurea; Commentaires du type: Qv 15; Débit max.: 30.0 m³/h; Débit min.: 30.0 m³/h; Flux: 30.0 m³/h; DN: 0.08 m; _Table: ANJOS-aurea; Distance: 0.0285 m; Génie climatique - Débit - Débit: 0.0 m³/h; Perte de charge: 8.0 Pa; Vitesse écoulement: 4.2 m/s; Revizto - Mechanical: yes; Données - Niveau de puissance acoustique (dB(A)): 23
203_VMC ATLANTIC | Family | 203_VMC ATLANTIC | N0 FINI
HYGROCOSY BC FLEX | Type | HYGROCOSY BC FLEX | N0 FINI
203_VMC ATLANTIC | HYGROCOSY BC FLEX | 203_VMC ATLANTIC | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1508818 | Bouche d'aération | 2021_015 | Autre - Famille et type: HYGROCOSY BC FLEX; Famille: HYGROCOSY BC FLEX; Type: HYGROCOSY BC FLEX; ID du type: HYGROCOSY BC FLEX; Piquage 1 _ BOUCHON: no; Piquage 1 _ DN 80 SDB/WC: no; Piquage 1 _ DN 125 CUISINE: yes; Piquage 2 _ BOUCHON: no; Piquage 2 _ DN 80 SDB/WC: yes; Piquage 2 _ DN 125 CUISINE: no; Piquage 3 _ BOUCHON: no; Piquage 3 _ DN 80 SDB/WC: yes; Piquage 3 _ DN 125 CUISINE: no; Piquage 4 _ BOUCHON: no; Piquage 4 _ DN 80 SDB/WC: yes; Piquage 4 _ DN 125 CUISINE: no; Piquage 5 _ BOUCHON: no; Piquage 5 _ DN 80 SDB/WC: yes; Piquage 5 _ DN 125 CUISINE: no; Piquage 1.Visibilité: yes; Piquage 2.Visibilité: yes; Piquage 3.Visibilité: yes; Piquage 4.Visibilité: yes; Piquage 5.Visibilité: yes; Marquage Atlantic: yes; Zone de maintenance: yes; Marquage BC: no; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: AIRHANDLER; Exporter au format IFC sous: IfcUnitaryEquipmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Extraction d'air,Reprise; Nom du système: Génie climatique Reprise 2,Génie climatique Reprise 1; Type de système: Reprise; Cotes - Volume: 0.0591253 m3; Surface: 0.779397 m2; Taille: ø160-ø150-ø125-ø125-ø80-ø80; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Hôte: <non associé>; Élévation par rapport au niveau: 2.779 m; Niveau de nomenclature: N0 FINI; Type de Revit - Id: 1490579; Nom: HYGROCOSY BC FLEX; Elévation par défaut: 1.2192 m; Catégorie: Bouche d'aération; Exporter le type au format IFC: 0; Modèle: HYGROCOSY BC FLEX; Fabricant: Atlantic; URL: https://www.atlantic-climatisation-ventilation.fr/; Description: VMC simple flux hygroréglable basse consommation - espace réduit; Sous-projet: Famille : Bouche d'aération : 203_VMC ATLANTIC; Nom de la famille: 203_VMC ATLANTIC; Nom du type: HYGROCOSY BC FLEX; Code article: 412279; Famille: VMC pavillonnaire; Lien page produit: https://www.atlantic-thermor-prescription.fr/nos-produits/hygrocosy-bc-flex; Copyright: ©2020 Atlantic Climatisation & Ventilation. Tous droits réservés.; Hauteur hors options: 0.331 m; Largeur hors options: 0.39 m; Profondeur hors options: 0.33 m; Poids à vide hors options: 2.00 kg; Dimensions d'installation y compris option(s): 390 x 330 x 331; Réseau (mono/tri): Monophasé; Tension d'alimentation: 230 V; Fréquence: 50 Hz; Protection électrique: 2 A; Indice de protection (IP): NC; Garantie produit: 2 ans; Garantie pièces détachées: 1 an; Lien pièces détachées: https://atlantic.plateforme-services.com/; Lien fiche Pep: NC; Etiquette énergie (disponible sur nos sites): B; Période de vente du produit (depuis le / à partir de): 02-2020; Débit maxi (m3/h): 227,4 m3/h; Lien données RT (Edibatec): données accessibles via le plugin dans les logiciels RT; Puissance nominale absorbée: 46 W; Corps.Largeur: 0.379 m; Corps.Longueur: 0.372 m; Pattes.Longueur: 0.007 m; Corps.Hauteur: 0.15 m; Corps.Décroché: 0.02 m; Pattes.Deport: 0.025 m; Pattes.Largeur: 0.03 m; Piquages.Longueur: 0.09 m; Piquages.Position: 0.102 m; Intervalle de nettoyage: 1 an; Certificat CSTBAT: oui (voir site https://www.atlantic-climatisation-ventilation.fr/); BIM Créateur: FAUCONNET INGENIERIE; Diamètre raccordement rejet: 0.16 m; Diamètre raccordement sanitaire (x4): 0.08 m; Diamètre raccordement cuisine: 0.125 m; Matériau caisson: plastique polypro; Puissance électrique pondérée: 9,3 W Th-C (pour un T4, 1 SDB, 1 WC, en Hygro B); Puissance acoustique bouche de cuisine: 30,8 dB(A); Pression acoustique bouche de cuisine à 2 m et petite vitesse: 16,8 dB(A); KIT TWIST&GO + BOUCHE HYGRO SDB 10/40 D80 GRIFFES: 542576; KIT TWIST&GO + BOUCHE HYGRO WC 5-30 PILES (DETECTION PRESENCE) D80 GRIFFES: 526595; KIT TWIST&GO + BOUCHE HYGRO SDB 5/40 D80 GRIFFES: 542574; Chapeau de toiture Ø160: 422962; Conduit souple isolé Ø160 (rejet): 423142; Conduit souple isolé Ø125 (cusine): 423053; Conduit souple isolé Ø80 (sanitaires): 423050; ENTREE D'AIR HYGRO COMPACTE 5/45 + GRILLE FACADE ATTENUATION 34DB BLANC: 526602; Génie climatique - Débit - Débit: 0.0 m³/h; Trajectoire critique: no; Piquage 1.Debit: 0.0 m³/h; Piquage 1.Debit1_Dedoubleur: 0.0 m³/h; Piquage 2.Debit: 0.0 m³/h; Piquage 2.Debit2_Dedoubleur: 0.0 m³/h; Piquage 2.Debit1_Dedoubleur: 0.0 m³/h; Piquage 1.Debit2_Dedoubleur: 0.0 m³/h; Piquage 3.Debit: 0.0 m³/h; Piquage 3.Debit1_Dedoubleur: 0.0 m³/h; Piquage 3.Debit2_Dedoubleur: 0.0 m³/h; Piquage 4.Debit: 0.0 m³/h; Piquage 4.Debit1_Dedoubleur: 0.0 m³/h; Piquage 4.Debit2_Dedoubleur: 0.0 m³/h; Piquage 5.Debit: 0.0 m³/h; Piquage 5.Debit1_Dedoubleur: 0.0 m³/h; Piquage 5.Debit2_Dedoubleur: 0.0 m³/h; Sortie.Debit: 0.0 m³/h; Revizto - Mechanical: yes; Construction - Piquage 1.Diam: 0.125 m; Piquage 2.Diam: 0.08 m; Piquage 3.Diam: 0.08 m; Piquage 4.Diam: 0.15 m; Piquage 5.Diam: 0.125 m
203_VMC ATLANTIC | Instance | 203_VMC ATLANTIC | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1512565 | Bouche d'aération | Famille : Bouche d'aération : 203_VMC ATLANTIC | Autre - Nom de la famille: 203_VMC ATLANTIC; Données d'identification - Modèle: HYGROCOSY BC FLEX; Fabricant: Atlantic; URL: https://www.atlantic-climatisation-ventilation.fr/; Description: VMC simple flux hygroréglable basse consommation - espace réduit; Nom du type: HYGROCOSY BC FLEX; Code article: 412279; Famille: VMC pavillonnaire; Lien page produit: https://www.atlantic-thermor-prescription.fr/nos-produits/hygrocosy-bc-flex; Copyright: ©2020 Atlantic Climatisation & Ventilation. Tous droits réservés.; BIM Créateur: FAUCONNET INGENIERIE; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Hauteur hors options: 0.331 m; Largeur hors options: 0.39 m; Profondeur hors options: 0.33 m; Poids à vide hors options: 2.00 kg; Dimensions d'installation y compris option(s): 390 x 330 x 331; Diamètre raccordement rejet: 0.16 m; Diamètre raccordement sanitaire (x4): 0.08 m; Diamètre raccordement cuisine: 0.125 m; Electrique - Réseau (mono/tri): Monophasé; Tension d'alimentation: 230 V; Fréquence: 50 Hz; Protection électrique: 2 A; Indice de protection (IP): NC; Puissance nominale absorbée: 46 W; Puissance électrique pondérée: 9,3 W Th-C (pour un T4, 1 SDB, 1 WC, en Hygro B); Général - Garantie produit: 2 ans; Garantie pièces détachées: 1 an; Lien pièces détachées: https://atlantic.plateforme-services.com/; Intervalle de nettoyage: 1 an; KIT TWIST&GO + BOUCHE HYGRO SDB 10/40 D80 GRIFFES: 542576; KIT TWIST&GO + BOUCHE HYGRO WC 5-30 PILES (DETECTION PRESENCE) D80 GRIFFES: 526595; KIT TWIST&GO + BOUCHE HYGRO SDB 5/40 D80 GRIFFES: 542574; Chapeau de toiture Ø160: 422962; Conduit souple isolé Ø160 (rejet): 423142; Conduit souple isolé Ø125 (cusine): 423053; Conduit souple isolé Ø80 (sanitaires): 423050; ENTREE D'AIR HYGRO COMPACTE 5/45 + GRILLE FACADE ATTENUATION 34DB BLANC: 526602; Données - Lien fiche Pep: NC; Etiquette énergie (disponible sur nos sites): B; Période de vente du produit (depuis le / à partir de): 02-2020; Débit maxi (m3/h): 227,4 m3/h; Lien données RT (Edibatec): données accessibles via le plugin dans les logiciels RT; Certificat CSTBAT: oui (voir site https://www.atlantic-climatisation-ventilation.fr/); Puissance acoustique bouche de cuisine: 30,8 dB(A); Pression acoustique bouche de cuisine à 2 m et petite vitesse: 16,8 dB(A); Construction - Corps.Largeur: 0.379 m; Corps.Longueur: 0.372 m; Pattes.Longueur: 0.007 m; Corps.Hauteur: 0.15 m; Corps.Décroché: 0.02 m; Pattes.Deport: 0.025 m; Pattes.Largeur: 0.03 m; Piquages.Longueur: 0.09 m; Piquages.Position: 0.102 m; Matériaux et finitions - Matériau caisson: plastique polypro
Gaine | Category | Gaine | N0 FINI
Gaine circulaire | Family | Gaine circulaire | N0 FINI
Té / Coude segmenté | Type | Té / Coude segmenté | N0 FINI
Gaine circulaire | Té / Coude segmenté | Gaine circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1511659 | Gaine | 2021_015 | Autre - Famille et type: Té / Coude segmenté; Famille: Té / Coude segmenté; Type: Té / Coude segmenté; ID du type: Té / Coude segmenté; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 1; Type de système: Reprise; Surface: 0.757693 m2; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 1037439; Nom: Té / Coude segmenté; Catégorie: Gaine; Exporter le type au format IFC: 0; Sous-projet: Gaine; Nom de la famille: Gaine circulaire; Nom du type: Té / Coude segmenté; Rugosité: 0 m; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Trajectoire critique: no; Diamètre hydraulique: 0.125 m; Contraintes - Arase inférieure à son extrémité aval: 2.59369 m; Arase supérieure à son extrémité amont: 2.76248 m; Arase supérieure à son extrémité aval: 2.71865 m; Arase inférieure à son extrémité amont: 2.63752 m; Elévation de l'axe à son extrémité aval: 2.65617 m; Elévation de l'axe à son extrémité amont: 2.7 m; Inclinaison: 2.27%; Elévation du milieu: 2.7 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.65617 m; Élévation centrale de départ: 2.7 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø125 mm; Arase inférieure avec isolant à son extrémité aval: 2.59369 m; Arase supérieure avec isolant à son extrémité aval: 2.71865 m; Arase inférieure avec isolant à son extrémité amont: 2.63752 m; Arase supérieure avec isolant à son extrémité amont: 2.76248 m; Cotes - Taille: ø125; Longueur: 1.92945 m; Diamètre: 0.125 m; Revizto - Mechanical: yes; Revêtement - Taille libre: ø125 mm; Epaisseur du revêtement: 0 m
Gaine circulaire | Té / Coude segmenté | Gaine circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1511671 | Gaine | 2021_015 | Autre - Famille et type: Té / Coude segmenté; Famille: Té / Coude segmenté; Type: Té / Coude segmenté; ID du type: Té / Coude segmenté; Paramètres IFC - Exporter au format IFC: 0; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 1; Type de système: Reprise; Surface: 0.0742201 m2; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 1037439; Nom: Té / Coude segmenté; Catégorie: Gaine; Exporter le type au format IFC: 0; Sous-projet: Gaine; Nom de la famille: Gaine circulaire; Nom du type: Té / Coude segmenté; Rugosité: 0 m; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Trajectoire critique: no; Diamètre hydraulique: 0.125 m; Contraintes - Arase inférieure à son extrémité aval: 2.6415 m; Arase supérieure à son extrémité amont: 2.7665 m; Arase supérieure à son extrémité aval: 2.7665 m; Arase inférieure à son extrémité amont: 2.6415 m; Elévation de l'axe à son extrémité aval: 2.704 m; Elévation de l'axe à son extrémité amont: 2.704 m; Inclinaison: 0.00%; Elévation du milieu: 2.704 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.704 m; Élévation centrale de départ: 2.704 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø125 mm; Arase inférieure avec isolant à son extrémité aval: 2.6415 m; Arase supérieure avec isolant à son extrémité aval: 2.7665 m; Arase inférieure avec isolant à son extrémité amont: 2.6415 m; Arase supérieure avec isolant à son extrémité amont: 2.7665 m; Cotes - Taille: ø125; Longueur: 0.189 m; Diamètre: 0.125 m; Revizto - Mechanical: yes; Revêtement - Taille libre: ø125 mm; Epaisseur du revêtement: 0 m
Gaine circulaire | Té / Coude segmenté | Gaine circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1512723 | Gaine | 2021_015 | Autre - Famille et type: Té / Coude segmenté; Famille: Té / Coude segmenté; Type: Té / Coude segmenté; ID du type: Té / Coude segmenté; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Surface: 2.12282 m2; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 1037439; Nom: Té / Coude segmenté; Catégorie: Gaine; Exporter le type au format IFC: 0; Sous-projet: Gaine; Nom de la famille: Gaine circulaire; Nom du type: Té / Coude segmenté; Rugosité: 0 m; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Trajectoire critique: no; Diamètre hydraulique: 0.15 m; Contraintes - Arase inférieure à son extrémité aval: 2.629 m; Arase supérieure à son extrémité amont: 2.779 m; Arase supérieure à son extrémité aval: 2.779 m; Arase inférieure à son extrémité amont: 2.629 m; Elévation de l'axe à son extrémité aval: 2.704 m; Elévation de l'axe à son extrémité amont: 2.704 m; Inclinaison: 0.00%; Elévation du milieu: 2.704 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.704 m; Élévation centrale de départ: 2.704 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø150 mm; Arase inférieure avec isolant à son extrémité aval: 2.629 m; Arase supérieure avec isolant à son extrémité aval: 2.779 m; Arase inférieure avec isolant à son extrémité amont: 2.629 m; Arase supérieure avec isolant à son extrémité amont: 2.779 m; Cotes - Taille: ø150; Longueur: 4.50477 m; Diamètre: 0.15 m; Revizto - Mechanical: yes; Revêtement - Taille libre: ø150 mm; Epaisseur du revêtement: 0 m
Gaine circulaire | Té / Coude segmenté | Gaine circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513062 | Gaine | 2021_015 | Autre - Famille et type: Té / Coude segmenté; Famille: Té / Coude segmenté; Type: Té / Coude segmenté; ID du type: Té / Coude segmenté; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Surface: 0.149791 m2; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 1037439; Nom: Té / Coude segmenté; Catégorie: Gaine; Exporter le type au format IFC: 0; Sous-projet: Gaine; Nom de la famille: Gaine circulaire; Nom du type: Té / Coude segmenté; Rugosité: 0 m; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 3; Trajectoire critique: no; Diamètre hydraulique: 0.08 m; Contraintes - Arase inférieure à son extrémité aval: 2.56 m; Arase supérieure à son extrémité amont: 2.64 m; Arase supérieure à son extrémité aval: 2.64 m; Arase inférieure à son extrémité amont: 2.56 m; Elévation de l'axe à son extrémité aval: 2.6 m; Elévation de l'axe à son extrémité amont: 2.6 m; Inclinaison: 0.00%; Elévation du milieu: 2.6 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.6 m; Élévation centrale de départ: 2.6 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø80 mm; Arase inférieure avec isolant à son extrémité aval: 2.56 m; Arase supérieure avec isolant à son extrémité aval: 2.64 m; Arase inférieure avec isolant à son extrémité amont: 2.56 m; Arase supérieure avec isolant à son extrémité amont: 2.64 m; Cotes - Taille: ø80; Longueur: 0.596 m; Diamètre: 0.08 m; Revizto - Mechanical: yes; Revêtement - Taille libre: ø80 mm; Epaisseur du revêtement: 0 m
Gaine circulaire | Té / Coude segmenté | Gaine circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513064 | Gaine | 2021_015 | Autre - Famille et type: Té / Coude segmenté; Famille: Té / Coude segmenté; Type: Té / Coude segmenté; ID du type: Té / Coude segmenté; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Surface: 0.366184 m2; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 1037439; Nom: Té / Coude segmenté; Catégorie: Gaine; Exporter le type au format IFC: 0; Sous-projet: Gaine; Nom de la famille: Gaine circulaire; Nom du type: Té / Coude segmenté; Rugosité: 0 m; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 2; Trajectoire critique: no; Diamètre hydraulique: 0.08 m; Contraintes - Arase inférieure à son extrémité aval: 2.56 m; Arase supérieure à son extrémité amont: 2.64 m; Arase supérieure à son extrémité aval: 2.64 m; Arase inférieure à son extrémité amont: 2.56 m; Elévation de l'axe à son extrémité aval: 2.6 m; Elévation de l'axe à son extrémité amont: 2.6 m; Inclinaison: 0.00%; Elévation du milieu: 2.6 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.6 m; Élévation centrale de départ: 2.6 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø80 mm; Arase inférieure avec isolant à son extrémité aval: 2.56 m; Arase supérieure avec isolant à son extrémité aval: 2.64 m; Arase inférieure avec isolant à son extrémité amont: 2.56 m; Arase supérieure avec isolant à son extrémité amont: 2.64 m; Cotes - Taille: ø80; Longueur: 1.457 m; Diamètre: 0.08 m; Revizto - Mechanical: yes; Revêtement - Taille libre: ø80 mm; Epaisseur du revêtement: 0 m
Gaine circulaire | Té / Coude segmenté | Gaine circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513066 | Gaine | 2021_015 | Autre - Famille et type: Té / Coude segmenté; Famille: Té / Coude segmenté; Type: Té / Coude segmenté; ID du type: Té / Coude segmenté; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Surface: 0.312651 m2; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 1037439; Nom: Té / Coude segmenté; Catégorie: Gaine; Exporter le type au format IFC: 0; Sous-projet: Gaine; Nom de la famille: Gaine circulaire; Nom du type: Té / Coude segmenté; Rugosité: 0 m; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 2; Trajectoire critique: no; Diamètre hydraulique: 0.08 m; Contraintes - Arase inférieure à son extrémité aval: 2.56 m; Arase supérieure à son extrémité amont: 2.64 m; Arase supérieure à son extrémité aval: 2.64 m; Arase inférieure à son extrémité amont: 2.56 m; Elévation de l'axe à son extrémité aval: 2.6 m; Elévation de l'axe à son extrémité amont: 2.6 m; Inclinaison: 0.00%; Elévation du milieu: 2.6 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.6 m; Élévation centrale de départ: 2.6 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø80 mm; Arase inférieure avec isolant à son extrémité aval: 2.56 m; Arase supérieure avec isolant à son extrémité aval: 2.64 m; Arase inférieure avec isolant à son extrémité amont: 2.56 m; Arase supérieure avec isolant à son extrémité amont: 2.64 m; Cotes - Taille: ø80; Longueur: 1.244 m; Diamètre: 0.08 m; Revizto - Mechanical: yes; Revêtement - Taille libre: ø80 mm; Epaisseur du revêtement: 0 m
Gaine circulaire | Té / Coude segmenté | Gaine circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513068 | Gaine | 2021_015 | Autre - Famille et type: Té / Coude segmenté; Famille: Té / Coude segmenté; Type: Té / Coude segmenté; ID du type: Té / Coude segmenté; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 3; Type de système: Reprise; Surface: 0.273444 m2; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 1037439; Nom: Té / Coude segmenté; Catégorie: Gaine; Exporter le type au format IFC: 0; Sous-projet: Gaine; Nom de la famille: Gaine circulaire; Nom du type: Té / Coude segmenté; Rugosité: 0 m; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Trajectoire critique: no; Diamètre hydraulique: 0.08 m; Contraintes - Arase inférieure à son extrémité aval: 2.56 m; Arase supérieure à son extrémité amont: 2.64 m; Arase supérieure à son extrémité aval: 2.64 m; Arase inférieure à son extrémité amont: 2.56 m; Elévation de l'axe à son extrémité aval: 2.6 m; Elévation de l'axe à son extrémité amont: 2.6 m; Inclinaison: 0.00%; Elévation du milieu: 2.6 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.6 m; Élévation centrale de départ: 2.6 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø80 mm; Arase inférieure avec isolant à son extrémité aval: 2.56 m; Arase supérieure avec isolant à son extrémité aval: 2.64 m; Arase inférieure avec isolant à son extrémité amont: 2.56 m; Arase supérieure avec isolant à son extrémité amont: 2.64 m; Cotes - Taille: ø80; Longueur: 1.088 m; Diamètre: 0.08 m; Revizto - Mechanical: yes; Revêtement - Taille libre: ø80 mm; Epaisseur du revêtement: 0 m
Gaine circulaire | Té / Coude segmenté | Gaine circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513074 | Gaine | 2021_015 | Autre - Famille et type: Té / Coude segmenté; Famille: Té / Coude segmenté; Type: Té / Coude segmenté; ID du type: Té / Coude segmenté; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Surface: 1.27187 m2; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 1037439; Nom: Té / Coude segmenté; Catégorie: Gaine; Exporter le type au format IFC: 0; Sous-projet: Gaine; Nom de la famille: Gaine circulaire; Nom du type: Té / Coude segmenté; Rugosité: 0 m; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Trajectoire critique: no; Diamètre hydraulique: 0.15 m; Contraintes - Arase inférieure à son extrémité aval: 2.525 m; Arase supérieure à son extrémité amont: 2.675 m; Arase supérieure à son extrémité aval: 2.675 m; Arase inférieure à son extrémité amont: 2.525 m; Elévation de l'axe à son extrémité aval: 2.6 m; Elévation de l'axe à son extrémité amont: 2.6 m; Inclinaison: 0.00%; Elévation du milieu: 2.6 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.6 m; Élévation centrale de départ: 2.6 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø150 mm; Arase inférieure avec isolant à son extrémité aval: 2.525 m; Arase supérieure avec isolant à son extrémité aval: 2.675 m; Arase inférieure avec isolant à son extrémité amont: 2.525 m; Arase supérieure avec isolant à son extrémité amont: 2.675 m; Cotes - Taille: ø150; Longueur: 2.699 m; Diamètre: 0.15 m; Revizto - Mechanical: yes; Revêtement - Taille libre: ø150 mm; Epaisseur du revêtement: 0 m
Gaine circulaire | Té / Coude segmenté | Gaine circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513291 | Gaine | 2021_015 | Autre - Famille et type: Té / Coude segmenté; Famille: Té / Coude segmenté; Type: Té / Coude segmenté; ID du type: Té / Coude segmenté; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Surface: 0.455217 m2; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 1037439; Nom: Té / Coude segmenté; Catégorie: Gaine; Exporter le type au format IFC: 0; Sous-projet: Gaine; Nom de la famille: Gaine circulaire; Nom du type: Té / Coude segmenté; Rugosité: 0 m; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Trajectoire critique: no; Diamètre hydraulique: 0.15 m; Contraintes - Arase inférieure à son extrémité aval: 2.525 m; Arase supérieure à son extrémité amont: 2.675 m; Arase supérieure à son extrémité aval: 2.675 m; Arase inférieure à son extrémité amont: 2.525 m; Elévation de l'axe à son extrémité aval: 2.6 m; Elévation de l'axe à son extrémité amont: 2.6 m; Inclinaison: 0.00%; Elévation du milieu: 2.6 m; Justification verticale: 1; Justification horizontale: 1; Élévation centrale de fin: 2.6 m; Élévation centrale de départ: 2.6 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø150 mm; Arase inférieure avec isolant à son extrémité aval: 2.525 m; Arase supérieure avec isolant à son extrémité aval: 2.675 m; Arase inférieure avec isolant à son extrémité amont: 2.525 m; Arase supérieure avec isolant à son extrémité amont: 2.675 m; Cotes - Taille: ø150; Longueur: 0.966 m; Diamètre: 0.15 m; Revizto - Mechanical: yes; Revêtement - Taille libre: ø150 mm; Epaisseur du revêtement: 0 m
Gaine circulaire | Té / Coude segmenté | Gaine circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513326 | Gaine | 2021_015 | Autre - Famille et type: Té / Coude segmenté; Famille: Té / Coude segmenté; Type: Té / Coude segmenté; ID du type: Té / Coude segmenté; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Surface: 1.48858 m2; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 1037439; Nom: Té / Coude segmenté; Catégorie: Gaine; Exporter le type au format IFC: 0; Sous-projet: Gaine; Nom de la famille: Gaine circulaire; Nom du type: Té / Coude segmenté; Rugosité: 0 m; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Trajectoire critique: no; Diamètre hydraulique: 0.15 m; Contraintes - Arase inférieure à son extrémité aval: 2.55502 m; Arase supérieure à son extrémité amont: 2.77898 m; Arase supérieure à son extrémité aval: 2.70498 m; Arase inférieure à son extrémité amont: 2.62902 m; Elévation de l'axe à son extrémité aval: 2.63 m; Elévation de l'axe à son extrémité amont: 2.704 m; Inclinaison: 2.34%; Elévation du milieu: 2.63 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.704 m; Élévation centrale de départ: 2.63 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø150 mm; Arase inférieure avec isolant à son extrémité aval: 2.55502 m; Arase supérieure avec isolant à son extrémité aval: 2.70498 m; Arase inférieure avec isolant à son extrémité amont: 2.62902 m; Arase supérieure avec isolant à son extrémité amont: 2.77898 m; Cotes - Taille: ø150; Longueur: 3.15887 m; Diamètre: 0.15 m; Revizto - Mechanical: yes; Revêtement - Taille libre: ø150 mm; Epaisseur du revêtement: 0 m
Gaine circulaire | Té / Coude segmenté | Gaine circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513392 | Gaine | 2021_015 | Autre - Famille et type: Té / Coude segmenté; Famille: Té / Coude segmenté; Type: Té / Coude segmenté; ID du type: Té / Coude segmenté; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Surface: 1.21104 m2; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 1037439; Nom: Té / Coude segmenté; Catégorie: Gaine; Exporter le type au format IFC: 0; Sous-projet: Gaine; Nom de la famille: Gaine circulaire; Nom du type: Té / Coude segmenté; Rugosité: 0 m; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Trajectoire critique: no; Diamètre hydraulique: 0.15 m; Contraintes - Arase inférieure à son extrémité aval: 2.555 m; Arase supérieure à son extrémité amont: 2.705 m; Arase supérieure à son extrémité aval: 2.705 m; Arase inférieure à son extrémité amont: 2.555 m; Elévation de l'axe à son extrémité aval: 2.63 m; Elévation de l'axe à son extrémité amont: 2.63 m; Inclinaison: 0.00%; Elévation du milieu: 2.63 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.63 m; Élévation centrale de départ: 2.63 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø150 mm; Arase inférieure avec isolant à son extrémité aval: 2.555 m; Arase supérieure avec isolant à son extrémité aval: 2.705 m; Arase inférieure avec isolant à son extrémité amont: 2.555 m; Arase supérieure avec isolant à son extrémité amont: 2.705 m; Cotes - Taille: ø150; Longueur: 2.56991 m; Diamètre: 0.15 m; Revizto - Mechanical: yes; Revêtement - Taille libre: ø150 mm; Epaisseur du revêtement: 0 m
Gaine flexible | Category | Gaine flexible | N0 FINI
Gaine flexible circulaire | Family | Gaine flexible circulaire | N0 FINI
Gaine flexible circulaire | Souple - Circulaire | Gaine flexible circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1511991 | Gaine flexible | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 1; Type de système: Reprise; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 142444; Nom: Souple - Circulaire; Catégorie: Gaine flexible; Exporter le type au format IFC: 0; Sous-projet: Gaine flexible; Nom de la famille: Gaine flexible circulaire; Nom du type: Souple - Circulaire; Rugosité: 0.00009144 m; Type de jonction préférée: 1; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Trajectoire critique: no; Diamètre hydraulique: 0.125 m; Contraintes - Élévation centrale de départ: 2.704 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø125 mm; Cotes - Longueur: 0.391691 m; Diamètre: 0.125 m; Graphismes - Modèle de gaine flexible: 0; Revizto - Mechanical: yes; Revêtement - Taille libre: ø125 mm; Epaisseur du revêtement: 0 m
Gaine flexible circulaire | Souple - Circulaire | Gaine flexible circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1512468 | Gaine flexible | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 1; Type de système: Reprise; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 142444; Nom: Souple - Circulaire; Catégorie: Gaine flexible; Exporter le type au format IFC: 0; Sous-projet: Gaine flexible; Nom de la famille: Gaine flexible circulaire; Nom du type: Souple - Circulaire; Rugosité: 0.00009144 m; Type de jonction préférée: 1; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Trajectoire critique: no; Diamètre hydraulique: 0.125 m; Contraintes - Élévation centrale de départ: 2.65617 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø125 mm; Cotes - Longueur: 1.19036 m; Diamètre: 0.125 m; Graphismes - Modèle de gaine flexible: 0; Revizto - Mechanical: yes; Revêtement - Taille libre: ø125 mm; Epaisseur du revêtement: 0 m
Gaine flexible circulaire | Souple - Circulaire | Gaine flexible circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513076 | Gaine flexible | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 142444; Nom: Souple - Circulaire; Catégorie: Gaine flexible; Exporter le type au format IFC: 0; Sous-projet: Gaine flexible; Nom de la famille: Gaine flexible circulaire; Nom du type: Souple - Circulaire; Rugosité: 0.00009144 m; Type de jonction préférée: 1; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Trajectoire critique: no; Diamètre hydraulique: 0.15 m; Contraintes - Élévation centrale de départ: 2.6 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø150 mm; Cotes - Longueur: 0.548229 m; Diamètre: 0.15 m; Graphismes - Modèle de gaine flexible: 0; Revizto - Mechanical: yes; Revêtement - Taille libre: ø150 mm; Epaisseur du revêtement: 0 m
Gaine flexible circulaire | Souple - Circulaire | Gaine flexible circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513471 | Gaine flexible | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 142444; Nom: Souple - Circulaire; Catégorie: Gaine flexible; Exporter le type au format IFC: 0; Sous-projet: Gaine flexible; Nom de la famille: Gaine flexible circulaire; Nom du type: Souple - Circulaire; Rugosité: 0.00009144 m; Type de jonction préférée: 1; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Trajectoire critique: no; Diamètre hydraulique: 0.15 m; Contraintes - Élévation centrale de départ: 2.63 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø150 mm; Cotes - Longueur: 0.416046 m; Diamètre: 0.15 m; Graphismes - Modèle de gaine flexible: 0; Revizto - Mechanical: yes; Revêtement - Taille libre: ø150 mm; Epaisseur du revêtement: 0 m
Gaine flexible circulaire | Souple - Circulaire | Gaine flexible circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513492 | Gaine flexible | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 142444; Nom: Souple - Circulaire; Catégorie: Gaine flexible; Exporter le type au format IFC: 0; Sous-projet: Gaine flexible; Nom de la famille: Gaine flexible circulaire; Nom du type: Souple - Circulaire; Rugosité: 0.00009144 m; Type de jonction préférée: 1; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Trajectoire critique: no; Diamètre hydraulique: 0.15 m; Contraintes - Élévation centrale de départ: 2.63 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø150 mm; Cotes - Longueur: 0.298528 m; Diamètre: 0.15 m; Graphismes - Modèle de gaine flexible: 0; Revizto - Mechanical: yes; Revêtement - Taille libre: ø150 mm; Epaisseur du revêtement: 0 m
Gaine flexible circulaire | Souple - Circulaire | Gaine flexible circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513553 | Gaine flexible | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 142444; Nom: Souple - Circulaire; Catégorie: Gaine flexible; Exporter le type au format IFC: 0; Sous-projet: Gaine flexible; Nom de la famille: Gaine flexible circulaire; Nom du type: Souple - Circulaire; Rugosité: 0.00009144 m; Type de jonction préférée: 1; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Trajectoire critique: no; Diamètre hydraulique: 0.15 m; Contraintes - Élévation centrale de départ: 2.704 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø150 mm; Cotes - Longueur: 0.438527 m; Diamètre: 0.15 m; Graphismes - Modèle de gaine flexible: 0; Revizto - Mechanical: yes; Revêtement - Taille libre: ø150 mm; Epaisseur du revêtement: 0 m
