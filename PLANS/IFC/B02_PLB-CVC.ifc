Properties of the parts of a building model (IFC4), part 2 of 10

# IfcBuildingElementPart (358)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1336678 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.502101 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0518467 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 74; Contraintes - Arase inférieure à son extrémité aval: 0.489332 m; Arase supérieure à son extrémité amont: 0.510668 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.492101 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.492101 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.507899 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.507899 m; Arase supérieure à son extrémité aval: 0.510668 m; Arase inférieure à son extrémité amont: 0.489332 m; Elévation de l'axe à son extrémité aval: 0.5 m; Elévation de l'axe à son extrémité amont: 0.5 m; Inclinaison: 0.00%; Elévation du milieu: 0.5 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.5 m; Élévation centrale de départ: 0.5 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.489332 m; Arase supérieure avec isolant à son extrémité aval: 0.510668 m; Arase inférieure avec isolant à son extrémité amont: 0.489332 m; Arase supérieure avec isolant à son extrémité amont: 0.510668 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 1.10022 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1336680 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.619453 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0471946 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 71; Contraintes - Arase inférieure à son extrémité aval: 0.60945 m; Arase supérieure à son extrémité amont: 1.61097 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.609453 m; Elévation du fond (fil d'eau) à son extrémité amont: 1.61095 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.609468 m; Elévation du point haut intérieur du tube à son extrémité amont: 1.61097 m; Arase supérieure à son extrémité aval: 0.60947 m; Arase inférieure à son extrémité amont: 1.61095 m; Elévation de l'axe à son extrémité aval: 0.60946 m; Elévation de l'axe à son extrémité amont: 1.61096 m; Inclinaison: 106665.99%; Elévation du milieu: 0.60946 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 1.61096 m; Élévation centrale de départ: 0.60946 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.60945 m; Arase supérieure avec isolant à son extrémité aval: 0.60947 m; Arase inférieure avec isolant à son extrémité amont: 1.61095 m; Arase supérieure avec isolant à son extrémité amont: 1.61097 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 1.0015 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1336702 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.502099 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0514035 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 59; Contraintes - Arase inférieure à son extrémité aval: 0.489331 m; Arase supérieure à son extrémité amont: 0.510667 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.492099 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.492099 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.507898 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.507898 m; Arase supérieure à son extrémité aval: 0.510667 m; Arase inférieure à son extrémité amont: 0.489331 m; Elévation de l'axe à son extrémité aval: 0.499999 m; Elévation de l'axe à son extrémité amont: 0.499999 m; Inclinaison: 0.00%; Elévation du milieu: 0.499999 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.499999 m; Élévation centrale de départ: 0.499999 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.489331 m; Arase supérieure avec isolant à son extrémité aval: 0.510667 m; Arase inférieure avec isolant à son extrémité amont: 0.489331 m; Arase supérieure avec isolant à son extrémité amont: 0.510667 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 1.09082 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1336704 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.624454 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0469589 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 44; Contraintes - Arase inférieure à son extrémité aval: 0.614451 m; Arase supérieure à son extrémité amont: 1.61097 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.614454 m; Elévation du fond (fil d'eau) à son extrémité amont: 1.61095 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.614469 m; Elévation du point haut intérieur du tube à son extrémité amont: 1.61097 m; Arase supérieure à son extrémité aval: 0.614471 m; Arase inférieure à son extrémité amont: 1.61095 m; Elévation de l'axe à son extrémité aval: 0.614461 m; Elévation de l'axe à son extrémité amont: 1.61096 m; Inclinaison: 106469.69%; Elévation du milieu: 0.614461 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 1.61096 m; Élévation centrale de départ: 0.614461 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.614451 m; Arase supérieure avec isolant à son extrémité aval: 0.614471 m; Arase inférieure avec isolant à son extrémité amont: 1.61095 m; Arase supérieure avec isolant à son extrémité amont: 1.61097 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 0.996499 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1344673 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 1.69664 m; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00725096 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00171592; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 81; Contraintes - Arase inférieure à son extrémité aval: 1.68326 m; Arase supérieure à son extrémité amont: 1.71666 m; Elévation du fond (fil d'eau) à son extrémité aval: 1.68664 m; Elévation du fond (fil d'eau) à son extrémité amont: 1.68664 m; Elévation du point haut intérieur du tube à son extrémité aval: 1.71328 m; Elévation du point haut intérieur du tube à son extrémité amont: 1.71328 m; Arase supérieure à son extrémité aval: 1.71666 m; Arase inférieure à son extrémité amont: 1.68326 m; Elévation de l'axe à son extrémité aval: 1.69996 m; Elévation de l'axe à son extrémité amont: 1.69996 m; Inclinaison: 0.00%; Elévation du milieu: 1.69996 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 1.69996 m; Élévation centrale de départ: 1.69996 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm; Arase inférieure avec isolant à son extrémité aval: 1.68326 m; Arase supérieure avec isolant à son extrémité aval: 1.71666 m; Arase inférieure avec isolant à son extrémité amont: 1.68326 m; Arase supérieure avec isolant à son extrémité amont: 1.71666 m; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Taille: ø25 mm; Longueur: 0.0923221 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1344739 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 1.69664 m; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0957132 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00171592; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 54; Contraintes - Arase inférieure à son extrémité aval: 1.68326 m; Arase supérieure à son extrémité amont: 1.71666 m; Elévation du fond (fil d'eau) à son extrémité aval: 1.68664 m; Elévation du fond (fil d'eau) à son extrémité amont: 1.68664 m; Elévation du point haut intérieur du tube à son extrémité aval: 1.71328 m; Elévation du point haut intérieur du tube à son extrémité amont: 1.71328 m; Arase supérieure à son extrémité aval: 1.71666 m; Arase inférieure à son extrémité amont: 1.68326 m; Elévation de l'axe à son extrémité aval: 1.69996 m; Elévation de l'axe à son extrémité amont: 1.69996 m; Inclinaison: 0.00%; Elévation du milieu: 1.69996 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 1.69996 m; Élévation centrale de départ: 1.69996 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm; Arase inférieure avec isolant à son extrémité aval: 1.68326 m; Arase supérieure avec isolant à son extrémité aval: 1.71666 m; Arase inférieure avec isolant à son extrémité amont: 1.68326 m; Arase supérieure avec isolant à son extrémité amont: 1.71666 m; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Taille: ø25 mm; Longueur: 1.21866 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1344825 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 1.70206 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.100356 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 55; Contraintes - Arase inférieure à son extrémité aval: 1.68929 m; Arase supérieure à son extrémité amont: 1.71063 m; Elévation du fond (fil d'eau) à son extrémité aval: 1.69206 m; Elévation du fond (fil d'eau) à son extrémité amont: 1.69206 m; Elévation du point haut intérieur du tube à son extrémité aval: 1.70786 m; Elévation du point haut intérieur du tube à son extrémité amont: 1.70786 m; Arase supérieure à son extrémité aval: 1.71063 m; Arase inférieure à son extrémité amont: 1.68929 m; Elévation de l'axe à son extrémité aval: 1.69996 m; Elévation de l'axe à son extrémité amont: 1.69996 m; Inclinaison: 0.00%; Elévation du milieu: 1.69996 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 1.69996 m; Élévation centrale de départ: 1.69996 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 1.68929 m; Arase supérieure avec isolant à son extrémité aval: 1.71063 m; Arase inférieure avec isolant à son extrémité amont: 1.68929 m; Arase supérieure avec isolant à son extrémité amont: 1.71063 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 2.12963 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345020 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.525901 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00205232 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 74; Contraintes - Arase inférieure à son extrémité aval: 0.515899 m; Arase supérieure à son extrémité amont: 0.55947 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.515901 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.559453 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.515916 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.559468 m; Arase supérieure à son extrémité aval: 0.515919 m; Arase inférieure à son extrémité amont: 0.55945 m; Elévation de l'axe à son extrémité aval: 0.515909 m; Elévation de l'axe à son extrémité amont: 0.55946 m; Inclinaison: 106665.99%; Elévation du milieu: 0.515909 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.55946 m; Élévation centrale de départ: 0.515909 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.515899 m; Arase supérieure avec isolant à son extrémité aval: 0.515919 m; Arase inférieure avec isolant à son extrémité amont: 0.55945 m; Arase supérieure avec isolant à son extrémité amont: 0.55947 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 0.0435515 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345054 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.5259 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00228804 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 59; Contraintes - Arase inférieure à son extrémité aval: 0.515897 m; Arase supérieure à son extrémité amont: 0.564471 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.5159 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.564454 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.515915 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.564469 m; Arase supérieure à son extrémité aval: 0.515918 m; Arase inférieure à son extrémité amont: 0.564451 m; Elévation de l'axe à son extrémité aval: 0.515907 m; Elévation de l'axe à son extrémité amont: 0.564461 m; Inclinaison: 106469.69%; Elévation du milieu: 0.515907 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.564461 m; Élévation centrale de départ: 0.515907 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.515897 m; Arase supérieure avec isolant à son extrémité aval: 0.515918 m; Arase inférieure avec isolant à son extrémité amont: 0.564451 m; Arase supérieure avec isolant à son extrémité amont: 0.564471 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 0.0485538 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345075 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.541765 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00215521 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 78; Contraintes - Arase inférieure à son extrémité aval: 0.531764 m; Arase supérieure à son extrémité amont: 0.577499 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.531765 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.577499 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.531765 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.577499 m; Arase supérieure à son extrémité aval: 0.531765 m; Arase inférieure à son extrémité amont: 0.577499 m; Elévation de l'axe à son extrémité aval: 0.531765 m; Elévation de l'axe à son extrémité amont: 0.577499 m; Elévation du milieu: 0.531765 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.577499 m; Élévation centrale de départ: 0.531765 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.531764 m; Arase supérieure avec isolant à son extrémité aval: 0.531765 m; Arase inférieure avec isolant à son extrémité amont: 0.577499 m; Arase supérieure avec isolant à son extrémité amont: 0.577499 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 0.0457349 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345081 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.637499 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0497907 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 55; Contraintes - Arase inférieure à son extrémité aval: 0.627499 m; Arase supérieure à son extrémité amont: 1.68409 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.627499 m; Elévation du fond (fil d'eau) à son extrémité amont: 1.68409 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.627499 m; Elévation du point haut intérieur du tube à son extrémité amont: 1.68409 m; Arase supérieure à son extrémité aval: 0.627499 m; Arase inférieure à son extrémité amont: 1.68409 m; Elévation de l'axe à son extrémité aval: 0.627499 m; Elévation de l'axe à son extrémité amont: 1.68409 m; Elévation du milieu: 1.68409 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.627499 m; Élévation centrale de départ: 1.68409 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.627499 m; Arase supérieure avec isolant à son extrémité aval: 0.627499 m; Arase inférieure avec isolant à son extrémité amont: 1.68409 m; Arase supérieure avec isolant à son extrémité amont: 1.68409 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 1.05659 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1348022 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 1.69664 m; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0674514 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00171592; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 81; Contraintes - Arase inférieure à son extrémité aval: 1.68326 m; Arase supérieure à son extrémité amont: 1.71666 m; Elévation du fond (fil d'eau) à son extrémité aval: 1.68664 m; Elévation du fond (fil d'eau) à son extrémité amont: 1.68664 m; Elévation du point haut intérieur du tube à son extrémité aval: 1.71328 m; Elévation du point haut intérieur du tube à son extrémité amont: 1.71328 m; Arase supérieure à son extrémité aval: 1.71666 m; Arase inférieure à son extrémité amont: 1.68326 m; Elévation de l'axe à son extrémité aval: 1.69996 m; Elévation de l'axe à son extrémité amont: 1.69996 m; Inclinaison: 0.00%; Elévation du milieu: 1.69996 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 1.69996 m; Élévation centrale de départ: 1.69996 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm; Arase inférieure avec isolant à son extrémité aval: 1.68326 m; Arase supérieure avec isolant à son extrémité aval: 1.71666 m; Arase inférieure avec isolant à son extrémité amont: 1.68326 m; Arase supérieure avec isolant à son extrémité amont: 1.71666 m; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Taille: ø25 mm; Longueur: 0.858818 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1348140 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 2.69668 m; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.193726 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00171592; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 81; Contraintes - Arase inférieure à son extrémité aval: 2.6833 m; Arase supérieure à son extrémité amont: 2.7167 m; Elévation du fond (fil d'eau) à son extrémité aval: 2.68668 m; Elévation du fond (fil d'eau) à son extrémité amont: 2.68668 m; Elévation du point haut intérieur du tube à son extrémité aval: 2.71332 m; Elévation du point haut intérieur du tube à son extrémité amont: 2.71332 m; Arase supérieure à son extrémité aval: 2.7167 m; Arase inférieure à son extrémité amont: 2.6833 m; Elévation de l'axe à son extrémité aval: 2.7 m; Elévation de l'axe à son extrémité amont: 2.7 m; Inclinaison: 0.00%; Elévation du milieu: 2.7 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.7 m; Élévation centrale de départ: 2.7 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm; Arase inférieure avec isolant à son extrémité aval: 2.6833 m; Arase supérieure avec isolant à son extrémité aval: 2.7167 m; Arase inférieure avec isolant à son extrémité amont: 2.6833 m; Arase supérieure avec isolant à son extrémité amont: 2.7167 m; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Taille: ø25 mm; Longueur: 2.4666 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1348851 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 1.73496 m; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0746159 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00171592; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 81; Contraintes - Arase inférieure à son extrémité aval: 1.72496 m; Arase supérieure à son extrémité amont: 2.675 m; Elévation du fond (fil d'eau) à son extrémité aval: 1.72496 m; Elévation du fond (fil d'eau) à son extrémité amont: 2.675 m; Elévation du point haut intérieur du tube à son extrémité aval: 1.72496 m; Elévation du point haut intérieur du tube à son extrémité amont: 2.675 m; Arase supérieure à son extrémité aval: 1.72496 m; Arase inférieure à son extrémité amont: 2.675 m; Elévation de l'axe à son extrémité aval: 1.72496 m; Elévation de l'axe à son extrémité amont: 2.675 m; Elévation du milieu: 1.72496 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.675 m; Élévation centrale de départ: 1.72496 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm; Arase inférieure avec isolant à son extrémité aval: 1.72496 m; Arase supérieure avec isolant à son extrémité aval: 1.72496 m; Arase inférieure avec isolant à son extrémité amont: 2.675 m; Arase supérieure avec isolant à son extrémité amont: 2.675 m; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Taille: ø25 mm; Longueur: 0.950039 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1349490 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.518014 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00102079 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 78; Contraintes - Arase inférieure à son extrémité aval: 0.505245 m; Arase supérieure à son extrémité amont: 0.526581 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.508014 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.508014 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.523812 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.523812 m; Arase supérieure à son extrémité aval: 0.526581 m; Arase inférieure à son extrémité amont: 0.505245 m; Elévation de l'axe à son extrémité aval: 0.515913 m; Elévation de l'axe à son extrémité amont: 0.515913 m; Inclinaison: 0.00%; Elévation du milieu: 0.515913 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.515913 m; Élévation centrale de départ: 0.515913 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.505245 m; Arase supérieure avec isolant à son extrémité aval: 0.526581 m; Arase inférieure avec isolant à son extrémité amont: 0.505245 m; Arase supérieure avec isolant à son extrémité amont: 0.526581 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 0.0216619 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1349491 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.510561 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.000121835 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 78; Contraintes - Arase inférieure à son extrémité aval: 0.498208 m; Arase supérieure à son extrémité amont: 0.517705 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.500561 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.501923 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.51399 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.515352 m; Arase supérieure à son extrémité aval: 0.516343 m; Arase inférieure à son extrémité amont: 0.49957 m; Elévation de l'axe à son extrémité aval: 0.507276 m; Elévation de l'axe à son extrémité amont: 0.508637 m; Inclinaison: 61.97%; Elévation du milieu: 0.508637 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.507276 m; Élévation centrale de départ: 0.508637 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.498208 m; Arase supérieure avec isolant à son extrémité aval: 0.516343 m; Arase inférieure avec isolant à son extrémité amont: 0.49957 m; Arase supérieure avec isolant à son extrémité amont: 0.517705 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 0.00258542 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1354918 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 5; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.565553 m; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00319186 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00111801; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Contraintes - Arase inférieure à son extrémité aval: 0.55187 m; Arase supérieure à son extrémité amont: 0.60013 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.555553 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.555553 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.596447 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.596447 m; Arase supérieure à son extrémité aval: 0.60013 m; Arase inférieure à son extrémité amont: 0.55187 m; Elévation de l'axe à son extrémité aval: 0.576 m; Elévation de l'axe à son extrémité amont: 0.576 m; Inclinaison: 0.00%; Elévation du milieu: 0.576 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.576 m; Élévation centrale de départ: 0.576 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm; Arase inférieure avec isolant à son extrémité aval: 0.55187 m; Arase supérieure avec isolant à son extrémité aval: 0.60013 m; Arase inférieure avec isolant à son extrémité amont: 0.55187 m; Arase supérieure avec isolant à son extrémité amont: 0.60013 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Taille: ø40 mm; Longueur: 0.0254 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1377789 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.001 m; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00322013 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00171592; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 87; Contraintes - Arase inférieure à son extrémité aval: -0.009 m; Arase supérieure à son extrémité amont: 0.032 m; Elévation du fond (fil d'eau) à son extrémité aval: -0.009 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.032 m; Elévation du point haut intérieur du tube à son extrémité aval: -0.009 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.032 m; Arase supérieure à son extrémité aval: -0.009 m; Arase inférieure à son extrémité amont: 0.032 m; Elévation de l'axe à son extrémité aval: -0.009 m; Elévation de l'axe à son extrémité amont: 0.032 m; Elévation du milieu: 0.032 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: -0.009 m; Élévation centrale de départ: 0.032 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm; Arase inférieure avec isolant à son extrémité aval: -0.009 m; Arase supérieure avec isolant à son extrémité aval: -0.009 m; Arase inférieure avec isolant à son extrémité amont: 0.032 m; Arase supérieure avec isolant à son extrémité amont: 0.032 m; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Taille: ø25 mm; Longueur: 0.041 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1377989 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 2.69668 m; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0374294 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00171592; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 83; Contraintes - Arase inférieure à son extrémité aval: 2.6833 m; Arase supérieure à son extrémité amont: 2.71674 m; Elévation du fond (fil d'eau) à son extrémité aval: 2.68668 m; Elévation du fond (fil d'eau) à son extrémité amont: 2.68672 m; Elévation du point haut intérieur du tube à son extrémité aval: 2.71333 m; Elévation du point haut intérieur du tube à son extrémité amont: 2.71337 m; Arase supérieure à son extrémité aval: 2.7167 m; Arase inférieure à son extrémité amont: 2.68334 m; Elévation de l'axe à son extrémité aval: 2.7 m; Elévation de l'axe à son extrémité amont: 2.70004 m; Inclinaison: 0.01%; Elévation du milieu: 2.70004 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.7 m; Élévation centrale de départ: 2.70004 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm; Arase inférieure avec isolant à son extrémité aval: 2.6833 m; Arase supérieure avec isolant à son extrémité aval: 2.7167 m; Arase inférieure avec isolant à son extrémité amont: 2.68334 m; Arase supérieure avec isolant à son extrémité amont: 2.71674 m; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Taille: ø25 mm; Longueur: 0.476566 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1378028 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 2.69666 m; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0118151 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00171592; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 84; Contraintes - Arase inférieure à son extrémité aval: 2.68328 m; Arase supérieure à son extrémité amont: 2.7167 m; Elévation du fond (fil d'eau) à son extrémité aval: 2.68666 m; Elévation du fond (fil d'eau) à son extrémité amont: 2.68667 m; Elévation du point haut intérieur du tube à son extrémité aval: 2.71331 m; Elévation du point haut intérieur du tube à son extrémité amont: 2.71332 m; Arase supérieure à son extrémité aval: 2.71668 m; Arase inférieure à son extrémité amont: 2.6833 m; Elévation de l'axe à son extrémité aval: 2.69998 m; Elévation de l'axe à son extrémité amont: 2.7 m; Inclinaison: 0.00%; Elévation du milieu: 2.7 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.69998 m; Élévation centrale de départ: 2.7 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm; Arase inférieure avec isolant à son extrémité aval: 2.68328 m; Arase supérieure avec isolant à son extrémité aval: 2.71668 m; Arase inférieure avec isolant à son extrémité amont: 2.6833 m; Arase supérieure avec isolant à son extrémité amont: 2.7167 m; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Taille: ø25 mm; Longueur: 0.150435 m
