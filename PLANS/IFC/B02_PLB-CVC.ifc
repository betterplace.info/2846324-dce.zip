Properties of the parts of a building model (IFC4), part 1 of 10

# File
Description: ViewDefinition [CoordinationView]
File name: B02_PLB.rvt.ifc
Time: 2025-08-25T15:37:30
Author: Mathéo Boulanger
Organization: CHU Caen
Written by: Revizto Hierarchic
Made in: ExportToIFC 5.16.5.39481

# IfcProject, CHU CAEN
Description: CHU CAEN

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 66.68 m

# IfcBuilding, B02_PLB.rvt
Description: CHU CAEN; LongName: B02_PLB.rvt; ElevationOfRefHeight: 0 m
Elément - Nom: B02_PLB.rvt; Type: Lien; Nom du fichier source: \\admin-srv2\Dir-Patr-inf\Commun\GestionPatrimoine\04_BIM\MN_PATRIMOINE\B02_DC\B02_PLB.rvt; Dernière Exportation: 2025-08-25T15:36:15; Dernier Exporté par: boulanger-mathe@chu-caen.fr
Revizto - Revizto Scene Data: base64(CAAqFDExNTk3MTk0NTEzMjMxNTk0OTYyMlpcXGFkbWluLXNydjJcRGlyLVBhdHItaW5mXENvbW11blxHZXN0aW9uUGF0cmltb2luZVwwNF9CSU1cTU5fUEFUUklNT0lORVxCMDJfRENcQjAyX1BMQi5ydnRRBUovGtY0WkNqC0IwMl9QTEIucnZ0eACAAQCIAQA=); Revizto Version: 5.16.5.39481; Revizto Scene UID: 4853249642612083205; Revizto Export Logic Version: 2

# IfcBuildingStorey (5)
In: B02_PLB.rvt
Description: Building Storey
Name | Elevation (m)
S1 | -3.01
N0 | -0.02
N1 | 3.49205
N2 | 6.54
N0 FINI | 0.01

# IfcBuildingElementPart (358)
In: B02_PLB.rvt
Elément - Fichier source: B02_PLB.rvt
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
Appareils sanitaires | Category | Appareils sanitaires | N0 FINI
Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame | Family | Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame | N0 FINI
Default | Type | Default | N0 FINI
Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame | Default | Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1335245 | Appareils sanitaires | 2021_015 | Autre - Famille et type: Default; Famille: Default; Type: Default; ID du type: Default; Control Pipe Angle: 140 deg; Pipe Diameter: 0.1 m; PVC100: PVC 100; PEHD90: PEHD 90; PEHD100: PEHD 100; PEHD110: PEHD 110; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: CISTERN; Exporter au format IFC sous: IfcSanitaryTerminalType; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire,Eau froide sanitaire; Nom du système: Eaux Usées 1,Eau Froide Sanitaire 1; Cotes - Volume: 0.0878795 m3; Surface: 0.846391 m2; Actual Pipe Length: 0.2 m; Actual Pipe Angle: -40 deg; Pipe Angle: -40 deg; Pipe Length: 0.2 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0 m; Construction - Vertical Pipe: yes; Flush plate: Album 90; Pipe Style: PEHD 100; Plomberie - Oulet Flow: 0.0 L/s; Inlet Flow: 0.1 L/s; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 716554; Nom: Default; Elévation par défaut: 0 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: Ingénio Auto-Portant; Fabricant: SIAMP; URL: https://www.siamp.fr/; Description: Self-supporting frame for wall hung WC; Titre OmniClass: Sanitary Equipment; Numéro OmniClass: 23.45.05.00; Description de l'assemblage: Plumbing Fixtures; Code d'assemblage: D2010; Sous-projet: Famille : Appareils sanitaires : Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame; Nom de la famille: Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame; Nom du type: Default; Actual Casing Depth: 0.05 m; Actual Depth: 0.2 m; Actual Height: 1.2 m; Edition number: 2; Product data url: https://bimobject.com/siamp/product/3131xx10; Casing Depth: 0.05 m; Depth: 0.2 m; Height: 1.2 m
2 x Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame | Instance | Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1347608 | Appareils sanitaires | Famille : Appareils sanitaires : Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame | Autre - Nom de la famille: Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame; Données d'identification - Modèle: Ingénio Auto-Portant; Fabricant: SIAMP; URL: https://www.siamp.fr/; Description: Self-supporting frame for wall hung WC; Titre OmniClass: Sanitary Equipment; Numéro OmniClass: 23.45.05.00; Description de l'assemblage: Plumbing Fixtures; Code d'assemblage: D2010; Nom du type: Default; Product data url: https://bimobject.com/siamp/product/3131xx10; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Actual Casing Depth: 0.05 m; Actual Depth: 0.2 m; Actual Height: 1.2 m; Casing Depth: 0.05 m; Depth: 0.2 m; Height: 1.2 m; Général - Edition number: 2
Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame | Default | Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1335247 | Appareils sanitaires | 2021_015 | Autre - Famille et type: Default; Famille: Default; Type: Default; ID du type: Default; Control Pipe Angle: 140 deg; Pipe Diameter: 0.1 m; PVC100: PVC 100; PEHD90: PEHD 90; PEHD100: PEHD 100; PEHD110: PEHD 110; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: CISTERN; Exporter au format IFC sous: IfcSanitaryTerminalType; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire,Eau froide sanitaire; Nom du système: Eaux Usées 1,Eau Froide Sanitaire 1; Cotes - Volume: 0.0878795 m3; Surface: 0.846391 m2; Actual Pipe Length: 0.155 m; Actual Pipe Angle: -40 deg; Pipe Angle: -40 deg; Pipe Length: 0 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0 m; Construction - Vertical Pipe: yes; Flush plate: Album 90; Pipe Style: PEHD 100; Plomberie - Oulet Flow: 0.0 L/s; Inlet Flow: 0.1 L/s; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 716554; Nom: Default; Elévation par défaut: 0 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: Ingénio Auto-Portant; Fabricant: SIAMP; URL: https://www.siamp.fr/; Description: Self-supporting frame for wall hung WC; Titre OmniClass: Sanitary Equipment; Numéro OmniClass: 23.45.05.00; Description de l'assemblage: Plumbing Fixtures; Code d'assemblage: D2010; Sous-projet: Famille : Appareils sanitaires : Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame; Nom de la famille: Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame; Nom du type: Default; Actual Casing Depth: 0.05 m; Actual Depth: 0.2 m; Actual Height: 1.2 m; Edition number: 2; Product data url: https://bimobject.com/siamp/product/3131xx10; Casing Depth: 0.05 m; Depth: 0.2 m; Height: 1.2 m
Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame | Instance | Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1347633 | Appareils sanitaires | Famille : Appareils sanitaires : Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame | Autre - Nom de la famille: Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame; Données d'identification - Modèle: Ingénio Auto-Portant; Fabricant: SIAMP; URL: https://www.siamp.fr/; Description: Self-supporting frame for wall hung WC; Titre OmniClass: Sanitary Equipment; Numéro OmniClass: 23.45.05.00; Description de l'assemblage: Plumbing Fixtures; Code d'assemblage: D2010; Nom du type: Default; Product data url: https://bimobject.com/siamp/product/3131xx10; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Actual Casing Depth: 0.05 m; Actual Depth: 0.2 m; Actual Height: 1.2 m; Casing Depth: 0.05 m; Depth: 0.2 m; Height: 1.2 m; Général - Edition number: 2
Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame | Default | Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1335251 | Appareils sanitaires | 2021_015 | Autre - Famille et type: Default; Famille: Default; Type: Default; ID du type: Default; Control Pipe Angle: 140 deg; Pipe Diameter: 0.1 m; PVC100: PVC 100; PEHD90: PEHD 90; PEHD100: PEHD 100; PEHD110: PEHD 110; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: CISTERN; Exporter au format IFC sous: IfcSanitaryTerminalType; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire,Eau froide sanitaire; Nom du système: Eaux Usées 1,Eau Froide Sanitaire 1; Cotes - Volume: 0.0878795 m3; Surface: 0.846391 m2; Actual Pipe Length: 0.2 m; Actual Pipe Angle: -40 deg; Pipe Angle: -40 deg; Pipe Length: 0.2 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0 m; Construction - Vertical Pipe: yes; Flush plate: Album 90; Pipe Style: PEHD 100; Plomberie - Oulet Flow: 0.0 L/s; Inlet Flow: 0.1 L/s; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 716554; Nom: Default; Elévation par défaut: 0 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: Ingénio Auto-Portant; Fabricant: SIAMP; URL: https://www.siamp.fr/; Description: Self-supporting frame for wall hung WC; Titre OmniClass: Sanitary Equipment; Numéro OmniClass: 23.45.05.00; Description de l'assemblage: Plumbing Fixtures; Code d'assemblage: D2010; Sous-projet: Famille : Appareils sanitaires : Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame; Nom de la famille: Sanitary_Toilet-Cisterns_SIAMP_Ingenio-Self-supporting-WC-Frame; Nom du type: Default; Actual Casing Depth: 0.05 m; Actual Depth: 0.2 m; Actual Height: 1.2 m; Edition number: 2; Product data url: https://bimobject.com/siamp/product/3131xx10; Casing Depth: 0.05 m; Depth: 0.2 m; Height: 1.2 m
740500 | Family | 740500 | N0 FINI
740500 | Type | 740500 | N0 FINI
740500 | 740500 | 740500 | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1335250 | Appareils sanitaires | 2021_015 | Autre - Famille et type: 740500; Famille: 740500; Type: 740500; ID du type: 740500; Paramètres IFC - Exporter au format IFC: 0; Exporter au format IFC sous: IfcFlowTerminal; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.000182659 m3; Surface: 0.013185 m2; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.8 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.8 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 716560; Nom: 740500; Elévation par défaut: 0 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: TEMPOSOFT 2; Fabricant: DELABIE; URL: http://www.delabie.fr/; Description: DELABIE, fabricant français, est le leader européen de l'équipement sanitaire pour les établissements recevant du public. Robinetteries, solutions pour personnes à mobilité réduite, appareils sanitaires, destinés aux écoles, lieux de loisirs, bureaux, hôpitaux, aéroports, ...; Sous-projet: Famille : Appareils sanitaires : 740500; Nom de la famille: 740500; Nom du type: 740500; Commentaires du type: Robinet temporisé; Finition: Laiton massif chromé; Raccordement: M1/2"; Hauteur: 0.075 m; Profondeur: 0.1 m; Radius: 0.0103 m; Référence: 740500; Famille de produits: Lavabo; Technologie: Temporisée; Débit l/min: 3 l/min à 3 bar; Lien fiche produit: http://www.delabie.fr/produits/740500; Lien notice d'installation: http://www.delabie.fr/produits/740500; Lien certification: http://www.delabie.fr/produits/740500; Lien CCTP: http://www.delabie.fr/produits/740500; Descriptif: Robinet temporisé de lavabo sur plage : Déclenchement souple. Temporisation ~7 sec. Débit préréglé à 3 l/min à 3 bar, ajustable de 1,5 à 6 l/min. Brise-jet antitartre inviolable. Corps en laiton massif chromé M1/2". Fixation par contre-écrou. Livré avec un repère bleu et un repère rouge.; Débit l/s: 0,05 l/s à 3 bar
3 x 740500 | Instance | 740500 | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 716560 | Appareils sanitaires | Famille : Appareils sanitaires : 740500 | Autre - Nom de la famille: 740500; Données d'identification - Modèle: TEMPOSOFT 2; Fabricant: DELABIE; URL: http://www.delabie.fr/; Description: DELABIE, fabricant français, est le leader européen de l'équipement sanitaire pour les établissements recevant du public. Robinetteries, solutions pour personnes à mobilité réduite, appareils sanitaires, destinés aux écoles, lieux de loisirs, bureaux, hôpitaux, aéroports, ...; Nom du type: 740500; Note d'identification: 100_PLOMBERIE SANITAIRES; Commentaires du type: Robinet temporisé; Référence: 740500; Famille de produits: Lavabo; Technologie: Temporisée; Raccordement: M1/2"; Hauteur: 0.075 m; Profondeur: 0.1 m; Débit l/min: 3 l/min à 3 bar; Finition: Laiton massif chromé; Lien fiche produit: http://www.delabie.fr/produits/740500; Lien notice d'installation: http://www.delabie.fr/produits/740500; Lien certification: http://www.delabie.fr/produits/740500; Lien CCTP: http://www.delabie.fr/produits/740500; Descriptif: Robinet temporisé de lavabo sur plage : Déclenchement souple. Temporisation ~7 sec. Débit préréglé à 3 l/min à 3 bar, ajustable de 1,5 à 6 l/min. Brise-jet antitartre inviolable. Corps en laiton massif chromé M1/2". Fixation par contre-écrou. Livré avec un repère bleu et un repère rouge.; Débit l/s: 0,05 l/s à 3 bar; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Radius: 0.0103 m
740500 | 740500 | 740500 | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1335256 | Appareils sanitaires | 2021_015 | Autre - Famille et type: 740500; Famille: 740500; Type: 740500; ID du type: 740500; Paramètres IFC - Exporter au format IFC: 0; Exporter au format IFC sous: IfcFlowTerminal; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.000182659 m3; Surface: 0.013185 m2; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.8 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.8 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 716560; Nom: 740500; Elévation par défaut: 0 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: TEMPOSOFT 2; Fabricant: DELABIE; URL: http://www.delabie.fr/; Description: DELABIE, fabricant français, est le leader européen de l'équipement sanitaire pour les établissements recevant du public. Robinetteries, solutions pour personnes à mobilité réduite, appareils sanitaires, destinés aux écoles, lieux de loisirs, bureaux, hôpitaux, aéroports, ...; Sous-projet: Famille : Appareils sanitaires : 740500; Nom de la famille: 740500; Nom du type: 740500; Commentaires du type: Robinet temporisé; Finition: Laiton massif chromé; Raccordement: M1/2"; Hauteur: 0.075 m; Profondeur: 0.1 m; Radius: 0.0103 m; Référence: 740500; Famille de produits: Lavabo; Technologie: Temporisée; Débit l/min: 3 l/min à 3 bar; Lien fiche produit: http://www.delabie.fr/produits/740500; Lien notice d'installation: http://www.delabie.fr/produits/740500; Lien certification: http://www.delabie.fr/produits/740500; Lien CCTP: http://www.delabie.fr/produits/740500; Descriptif: Robinet temporisé de lavabo sur plage : Déclenchement souple. Temporisation ~7 sec. Débit préréglé à 3 l/min à 3 bar, ajustable de 1,5 à 6 l/min. Brise-jet antitartre inviolable. Corps en laiton massif chromé M1/2". Fixation par contre-écrou. Livré avec un repère bleu et un repère rouge.; Débit l/s: 0,05 l/s à 3 bar
740500 | 740500 | 740500 | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1335332 | Appareils sanitaires | 2021_015 | Autre - Famille et type: 740500; Famille: 740500; Type: 740500; ID du type: 740500; Paramètres IFC - Exporter au format IFC: 0; Exporter au format IFC sous: IfcFlowTerminal; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.000182659 m3; Surface: 0.013185 m2; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.8 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.8 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 716560; Nom: 740500; Elévation par défaut: 0 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: TEMPOSOFT 2; Fabricant: DELABIE; URL: http://www.delabie.fr/; Description: DELABIE, fabricant français, est le leader européen de l'équipement sanitaire pour les établissements recevant du public. Robinetteries, solutions pour personnes à mobilité réduite, appareils sanitaires, destinés aux écoles, lieux de loisirs, bureaux, hôpitaux, aéroports, ...; Sous-projet: Famille : Appareils sanitaires : 740500; Nom de la famille: 740500; Nom du type: 740500; Commentaires du type: Robinet temporisé; Finition: Laiton massif chromé; Raccordement: M1/2"; Hauteur: 0.075 m; Profondeur: 0.1 m; Radius: 0.0103 m; Référence: 740500; Famille de produits: Lavabo; Technologie: Temporisée; Débit l/min: 3 l/min à 3 bar; Lien fiche produit: http://www.delabie.fr/produits/740500; Lien notice d'installation: http://www.delabie.fr/produits/740500; Lien certification: http://www.delabie.fr/produits/740500; Lien CCTP: http://www.delabie.fr/produits/740500; Descriptif: Robinet temporisé de lavabo sur plage : Déclenchement souple. Temporisation ~7 sec. Débit préréglé à 3 l/min à 3 bar, ajustable de 1,5 à 6 l/min. Brise-jet antitartre inviolable. Corps en laiton massif chromé M1/2". Fixation par contre-écrou. Livré avec un repère bleu et un repère rouge.; Débit l/s: 0,05 l/s à 3 bar
BC_Generic_Sink_LOD400 | Family | BC_Generic_Sink_LOD400 | N0 FINI
Generic Sink - 800 x 500 x 140 | Type | Generic Sink - 800 x 500 x 140 | N0 FINI
BC_Generic_Sink_LOD400 | Generic Sink - 800 x 500 x 140 | BC_Generic_Sink_LOD400 | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1335253 | Appareils sanitaires | 2021_015 | Autre - Famille et type: Generic Sink - 800 x 500 x 140; Famille: Generic Sink - 800 x 500 x 140; Type: Generic Sink - 800 x 500 x 140; ID du type: Generic Sink - 800 x 500 x 140; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SINK; Exporter au format IFC sous: IfcSanitaryTerminalType; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eau Froide Sanitaire 3,Eau Froide Sanitaire 5; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.00150737 m3; Surface: 0.746662 m2; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.9 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.9 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 732738; Nom: Generic Sink - 800 x 500 x 140; Elévation par défaut: 0 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: Generic Sink; URL: www.bimandco.com; Description: Stainless steel sink; Titre OmniClass: Sinks/Lavatories; Numéro OmniClass: 23.45.05.14.14; Sous-projet: Famille : Appareils sanitaires : BC_Generic_Sink_LOD400; Nom de la famille: BC_Generic_Sink_LOD400; Nom du type: Generic Sink - 800 x 500 x 140; Commentaires du type: Generic Sink - 800 x 500 x 140; Overall Height: 0.14 m; Overall Length: 0.8 m; Overall Width: 0.5 m; Bump Rack Length: 0.27 m; Repetition Bump Rack: 3; Repetition Bump Rack Verif: 3; Single Bump Rack: no; Bump Rack Network: yes; Main Material: Acier inoxydable AISI 304
BC_Generic_Sink_LOD400 | Instance | BC_Generic_Sink_LOD400 | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 732738 | Appareils sanitaires | Famille : Appareils sanitaires : BC_Generic_Sink_LOD400 | Autre - Nom de la famille: BC_Generic_Sink_LOD400; Données d'identification - Modèle: Generic Sink; URL: www.bimandco.com; Description: Stainless steel sink; Titre OmniClass: Sinks/Lavatories; Numéro OmniClass: 23.45.05.14.14; Nom du type: Generic Sink - 800 x 500 x 140; Note d'identification: 100_PLOMBERIE SANITAIRES; Commentaires du type: Generic Sink - 800 x 500 x 140; Contraintes - Elévation par défaut: 0 m; Bump Rack Length: 0.27 m; Repetition Bump Rack: 3; Repetition Bump Rack Verif: 3; Single Bump Rack: no; Bump Rack Network: yes; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Overall Height: 0.14 m; Overall Length: 0.8 m; Overall Width: 0.5 m; Matériaux et finitions - Main Material: Acier inoxydable AISI 304
POR_Okyris_D0580_BIM_FR | Family | POR_Okyris_D0580_BIM_FR | N0 FINI
Type1 | Type | Type1 | N0 FINI
POR_Okyris_D0580_BIM_FR | Type1 | POR_Okyris_D0580_BIM_FR | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1335254 | Appareils sanitaires | 2021_015 | Autre - Famille et type: Type1; Famille: Type1; Type: Type1; ID du type: Type1; Paramètres IFC - Exporter au format IFC: 0; Exporter au format IFC sous: IfcFlowTerminal; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau chaude sanitaire,Eau froide sanitaire; Nom du système: Eau Chaude Sanitaire 1,Eau Froide Sanitaire 1; Cotes - Volume: 0.000524038 m3; Surface: 0.0332184 m2; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.921605 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.921605 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 752642; Nom: Type1; Elévation par défaut: 0 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: D0580AA; Fabricant: prescription@idealstandard.fr; URL: www.idealspec.fr; Description: Mitigeur Evier Okyris - D0580AA / PORCHER; Sous-projet: Famille : Appareils sanitaires : POR_Okyris_D0580_BIM_FR; Nom de la famille: POR_Okyris_D0580_BIM_FR; Nom du type: Type1; Commentaires du type: n/a; Finition: Chrome; Raccordement: Plomberie; Hauteur: 0.2955 m; Profondeur: 0.2955 m; Référence: n/a; Type: Type prédéfini d'IFC: FAUCET; Exporter le type au format IFC sous: IfcValveType; Coût: 0.00; Accessoires: www.idealspec.fr; Caractéristiques: Mitigeur Evier Okyris - D0580AA / PORCHER; CodeBarre: n/a; Composants: n/a; Conformité: NF; ConseilsDInstallation: www.idealspec.fr; ContactGarantieDesPièces: n/a; Couleur: Chrome; CoûtDeRemplacement: 0; DateDeCréation: 22/12/2016; DébitL/Mn: n/a; DétailGarantie: year; Dimensions: 296 x 238 x 104 mm; DuréeDeGarantieDesPièces: 5; DuréeDeGarantieDeTravail: n/a; DuréeDeVie: n/a; DuréeGarantie: n/a; EffectuéPar: n/a; Espace: Interne; Forme: Complexe; GarantieDeTravail: n/a; Grade: n/a; LienUtile: sav@idealstandard.com; Marque: Porcher; Matériel: Laiton; PerformanceAccessibilité: NF; PerformanceDeDurabilité: n/a; PiècesDétachées: sav@idealstandard.com; PoidsBrut: n/a; PoidsNet: 0; Téléphone: 01.49.38.28.01; TypeDImmobilisation: n/a; UnitéDeMesure: mm; UnitéDeTemps: n/a; UnitéMonétaire: n/a; ZoneDeMesure: n/a; IfcExportAs: IfcValveType; IfcExportType: FAUCET; Auteur: www.idealstandardinternational.com; Bim-NomDuProjet: POR_Porcher_Sink Taps_D0580AA; InformationsProduit: n/a; Révision: n/a; Uniclass2015Code: Pr_40_20_87_84; Uniclass2015Title: Sink taps; Uniclass2015Version: Products v1.1; UrlDuFabricant: www.idealspec.fr; Largeur: 0.103391 m; Longueur: 0.237054 m; CoefficientDÉcoulement: n/a; Débit: 10; DescriptionDeLaRobinetterie: n/a; PressionDeFonctionnement: 3; PressionMaximum: n/a; TechnologieDeLaRobinetterie: Mural; TestDePression: 10; TypeDeRobinetterie: Mitigeur; UsageDeLaRobinetterie: Evier
POR_Okyris_D0580_BIM_FR | Instance | POR_Okyris_D0580_BIM_FR | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 752642 | Appareils sanitaires | Famille : Appareils sanitaires : POR_Okyris_D0580_BIM_FR | Autre - Nom de la famille: POR_Okyris_D0580_BIM_FR; Accessoires: www.idealspec.fr; Caractéristiques: Mitigeur Evier Okyris - D0580AA / PORCHER; CodeBarre: n/a; Composants: n/a; Conformité: NF; ConseilsDInstallation: www.idealspec.fr; ContactGarantieDesPièces: n/a; Couleur: Chrome; CoûtDeRemplacement: 0; DateDeCréation: 22/12/2016; DébitL/Mn: n/a; DétailGarantie: year; Dimensions: 296 x 238 x 104 mm; DuréeDeGarantieDesPièces: 5; DuréeDeGarantieDeTravail: n/a; DuréeDeVie: n/a; DuréeGarantie: n/a; EffectuéPar: n/a; Espace: Interne; Finition: Chrome; Forme: Complexe; GarantieDeTravail: n/a; Grade: n/a; LienUtile: sav@idealstandard.com; Marque: Porcher; Matériel: Laiton; Nom: Sink Taps_D0580AA_Porcher; PerformanceAccessibilité: NF; PerformanceDeDurabilité: n/a; PiècesDétachées: sav@idealstandard.com; PoidsBrut: n/a; PoidsNet: 0; Raccordement: Plomberie; Téléphone: 01.49.38.28.01; TypeDImmobilisation: n/a; UnitéDeMesure: mm; UnitéDeTemps: n/a; UnitéMonétaire: n/a; ZoneDeMesure: n/a; Hauteur: 0.2955 m; Largeur: 0.103391 m; Longueur: 0.237054 m; Profondeur: 0.2955 m; Référence: n/a; Données d'identification - Modèle: D0580AA; Fabricant: prescription@idealstandard.fr; URL: www.idealspec.fr; Description: Mitigeur Evier Okyris - D0580AA / PORCHER; Nom du type: Type1; Note d'identification: 100_PLOMBERIE SANITAIRES; Commentaires du type: n/a; Coût: 0.00; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: FAUCET; Exporter le type au format IFC sous: IfcValveType; IfcExportAs: IfcValveType; IfcExportType: FAUCET; CoefficientDÉcoulement: n/a; Débit: 10; DescriptionDeLaRobinetterie: n/a; PressionDeFonctionnement: 3; PressionMaximum: n/a; TechnologieDeLaRobinetterie: Mural; TestDePression: 10; TypeDeRobinetterie: Mitigeur; UsageDeLaRobinetterie: Evier; Général - Auteur: www.idealstandardinternational.com; Bim-NomDuProjet: POR_Porcher_Sink Taps_D0580AA; InformationsProduit: n/a; Révision: n/a; Uniclass2015Code: Pr_40_20_87_84; Uniclass2015Title: Sink taps; Uniclass2015Version: Products v1.1; UrlDuFabricant: www.idealspec.fr
39327000_Grohe_EuroCeramicHandrinseBasin37 | Family | 39327000_Grohe_EuroCeramicHandrinseBasin37 | N0 FINI
39327000 | Type | 39327000 | N0 FINI
39327000_Grohe_EuroCeramicHandrinseBasin37 | 39327000 | 39327000_Grohe_EuroCeramicHandrinseBasin37 | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513959 | Appareils sanitaires | 2021_015 | Autre - Famille et type: 39327000; Famille: 39327000; Type: 39327000; ID du type: 39327000; SerialNumber: Please Record On Commissioning.; WarrantyStartDate: Please Record On Commissioning.; AssetIdentifier: Please Record On Commissioning.; BarCode: Please Record On Commissioning.; InstallationDate: Please Record On Commissioning.; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SINK; Exporter au format IFC sous: IfcSanitaryTerminalType; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Cotes - Volume: 0.00529304 m3; Surface: 0.183596 m2; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 8.7983e-15 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 8.7983e-15 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 716558; Nom: 39327000; Elévation par défaut: 0 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: Euro Ceramic wallhung mini handrinse basin 37; Fabricant: Grohe Limited; URL: www.grohe.com; Description: Euro Ceramic Wallhung mini handrinse basin (37x18), Optional Proguard & HyperClean (00H), Vitreous china, Alpine White, 1 hole punched with overflow, 370 x 180 mm, 36 pcs per pallet; Titre OmniClass: Sanitary Equipment; Numéro OmniClass: 23.45.05.00; Description de l'assemblage: Plumbing Fixtures; Code d'assemblage: D2010; Sous-projet: Famille : Appareils sanitaires : 39327000_Grohe_EuroCeramicHandrinseBasin37; Nom de la famille: 39327000_Grohe_EuroCeramicHandrinseBasin37; Nom du type: 39327000; Commentaires du type: 39327000; Type: Type prédéfini d'IFC: IfcPipeFittingType; Exporter le type au format IFC sous: IfcPipeFitting; Coût: 0.00; Grade: 2017; IfcExportAs: IfcPipeFitting; IfcExportType: IfcPipeFittingType; WFU: 0; HWFU: 4.5; CWFU: 4.5; AssetType: Fixed; CreatedBy: info-uk@grohe.com; CreatedOn: 2017-08-01T09:00:00; ExpectedLife: 0; ModelNumber: 39327000; Ecojoy: no; ClassificationName: Uniclass2015; Material: Ceramic; PrimaryMaterial: Ceramic, White; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: Euro Ceramic wallhung mini handrinse basin 37; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: info-uk@grohe.com; WarrantyGuarantorParts: info-uk@grohe.com; _Author: Ian Holmes; _AuthorizedBy: Kris Atkinson; _BimSpecGuid: 0; _BSBibleVersion: 14; _CreatedBy: www.bimstore.co.uk; _CurrentRevision: 0; _DistributedBy: www.bimstore.co.uk; BIMObjectName: PlumbingFixture_GroheLimited_EuroCeramicHandrinseBasin37_39327000_METRIC; NBSDescription: Ceramic sinks; NBSObjectName: Grohe Limited - Ceramic sinks; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/340; NominalDepth: 0 m; NominalHeight: 0 m; NominalLength: 0 m; ColdWaterConnectionDiameter: 0.01 m; HotWaterConnectionDiameter: 0.01 m; ADACompliant: no; IndustryStandards: n/a; LEEDCredit: n/a; LowEmittingMaterial: no; MasterformatNumber: 01 52 19; MasterformatTitle: Sanitary Facilities; PercentageOfRecycledContent: n/a; ProductDocumentationLink: https://cdn.cloud.grohe.com/dimdraw/2000/2000/2090/2095/2095973/1500/2095973.jpg; ProductPageURL: https://www.grohe.co.uk/en_gb/euro-ceramic-mini-hand-rinse-basin-39327000.html; AccessibilityPerformance: n/a; ClassificationValue: Pr_40_20_96_15; CodePerformance: n/a; Color: White; Constituents: n/a; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; Features: Euro Ceramic Wallhung mini handrinse basin (37x18), Optional Proguard & HyperClean (00H), Vitreous china, Alpine White, 1 hole punched with overflow, 370 x 180 mm, 36 pcs per pallet; Finish: Ceramic; ManufacturerName: Grohe Limited; ModelReference: Euro Ceramic wallhung mini handrinse basin 37; ProductionYear: 2017; ReferencedStandard: n/a; ReplacementCost: n/a; Construction - OffsetFromLevel: 0.8 m
3 x 39327000_Grohe_EuroCeramicHandrinseBasin37 | Instance | 39327000_Grohe_EuroCeramicHandrinseBasin37 | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 716558 | Appareils sanitaires | Famille : Appareils sanitaires : 39327000_Grohe_EuroCeramicHandrinseBasin37 | Autre - Nom de la famille: 39327000_Grohe_EuroCeramicHandrinseBasin37; Grade: 2017; AssetType: Fixed; CreatedBy: info-uk@grohe.com; CreatedOn: 2017-08-01T09:00:00; ExpectedLife: 0; ModelNumber: 39327000; ClassificationName: Uniclass2015; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: Euro Ceramic wallhung mini handrinse basin 37; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: info-uk@grohe.com; WarrantyGuarantorParts: info-uk@grohe.com; AccessibilityPerformance: n/a; ClassificationValue: Pr_40_20_96_15; CodePerformance: n/a; Color: White; Constituents: n/a; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; Features: Euro Ceramic Wallhung mini handrinse basin (37x18), Optional Proguard & HyperClean (00H), Vitreous china, Alpine White, 1 hole punched with overflow, 370 x 180 mm, 36 pcs per pallet; Finish: Ceramic; ManufacturerName: Grohe Limited; Material: Ceramic; ModelReference: Euro Ceramic wallhung mini handrinse basin 37; ProductionYear: 2017; ReferencedStandard: n/a; ReplacementCost: n/a; Données d'identification - Modèle: Euro Ceramic wallhung mini handrinse basin 37; Fabricant: Grohe Limited; URL: www.grohe.com; Description: Euro Ceramic Wallhung mini handrinse basin (37x18), Optional Proguard & HyperClean (00H), Vitreous china, Alpine White, 1 hole punched with overflow, 370 x 180 mm, 36 pcs per pallet; Titre OmniClass: Sanitary Equipment; Numéro OmniClass: 23.45.05.00; Description de l'assemblage: Plumbing Fixtures; Code d'assemblage: D2010; Nom du type: 39327000; Note d'identification: 100_PLOMBERIE SANITAIRES; Commentaires du type: 39327000; Coût: 0.00; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: IfcPipeFittingType; Exporter le type au format IFC sous: IfcPipeFitting; IfcExportAs: IfcPipeFitting; IfcExportType: IfcPipeFittingType; NominalDepth: 0 m; NominalHeight: 0 m; NominalLength: 0 m; Génie climatique - WFU: 0; HWFU: 4.5; CWFU: 4.5; Matériaux et finitions - PrimaryMaterial: Ceramic, White; Propriétés du modèle - _Author: Ian Holmes; _AuthorizedBy: Kris Atkinson; _BimSpecGuid: 0; _BSBibleVersion: 14; _CreatedBy: www.bimstore.co.uk; _CurrentRevision: 0; _DistributedBy: www.bimstore.co.uk; BIMObjectName: PlumbingFixture_GroheLimited_EuroCeramicHandrinseBasin37_39327000_METRIC; NBSDescription: Ceramic sinks; NBSObjectName: Grohe Limited - Ceramic sinks; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/340; Cotes - ColdWaterConnectionDiameter: 0.01 m; HotWaterConnectionDiameter: 0.01 m; Données - ADACompliant: no; Ecojoy: no; IndustryStandards: n/a; LEEDCredit: n/a; LowEmittingMaterial: no; MasterformatNumber: 01 52 19; MasterformatTitle: Sanitary Facilities; PercentageOfRecycledContent: n/a; ProductDocumentationLink: https://cdn.cloud.grohe.com/dimdraw/2000/2000/2090/2095/2095973/1500/2095973.jpg; ProductPageURL: https://www.grohe.co.uk/en_gb/euro-ceramic-mini-hand-rinse-basin-39327000.html
39327000_Grohe_EuroCeramicHandrinseBasin37 | 39327000 | 39327000_Grohe_EuroCeramicHandrinseBasin37 | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513975 | Appareils sanitaires | 2021_015 | Autre - Famille et type: 39327000; Famille: 39327000; Type: 39327000; ID du type: 39327000; SerialNumber: Please Record On Commissioning.; WarrantyStartDate: Please Record On Commissioning.; AssetIdentifier: Please Record On Commissioning.; BarCode: Please Record On Commissioning.; InstallationDate: Please Record On Commissioning.; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SINK; Exporter au format IFC sous: IfcSanitaryTerminalType; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Cotes - Volume: 0.00529304 m3; Surface: 0.183596 m2; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: -2.77485e-15 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: -2.77485e-15 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 716558; Nom: 39327000; Elévation par défaut: 0 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: Euro Ceramic wallhung mini handrinse basin 37; Fabricant: Grohe Limited; URL: www.grohe.com; Description: Euro Ceramic Wallhung mini handrinse basin (37x18), Optional Proguard & HyperClean (00H), Vitreous china, Alpine White, 1 hole punched with overflow, 370 x 180 mm, 36 pcs per pallet; Titre OmniClass: Sanitary Equipment; Numéro OmniClass: 23.45.05.00; Description de l'assemblage: Plumbing Fixtures; Code d'assemblage: D2010; Sous-projet: Famille : Appareils sanitaires : 39327000_Grohe_EuroCeramicHandrinseBasin37; Nom de la famille: 39327000_Grohe_EuroCeramicHandrinseBasin37; Nom du type: 39327000; Commentaires du type: 39327000; Type: Type prédéfini d'IFC: IfcPipeFittingType; Exporter le type au format IFC sous: IfcPipeFitting; Coût: 0.00; Grade: 2017; IfcExportAs: IfcPipeFitting; IfcExportType: IfcPipeFittingType; WFU: 0; HWFU: 4.5; CWFU: 4.5; AssetType: Fixed; CreatedBy: info-uk@grohe.com; CreatedOn: 2017-08-01T09:00:00; ExpectedLife: 0; ModelNumber: 39327000; Ecojoy: no; ClassificationName: Uniclass2015; Material: Ceramic; PrimaryMaterial: Ceramic, White; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: Euro Ceramic wallhung mini handrinse basin 37; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: info-uk@grohe.com; WarrantyGuarantorParts: info-uk@grohe.com; _Author: Ian Holmes; _AuthorizedBy: Kris Atkinson; _BimSpecGuid: 0; _BSBibleVersion: 14; _CreatedBy: www.bimstore.co.uk; _CurrentRevision: 0; _DistributedBy: www.bimstore.co.uk; BIMObjectName: PlumbingFixture_GroheLimited_EuroCeramicHandrinseBasin37_39327000_METRIC; NBSDescription: Ceramic sinks; NBSObjectName: Grohe Limited - Ceramic sinks; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/340; NominalDepth: 0 m; NominalHeight: 0 m; NominalLength: 0 m; ColdWaterConnectionDiameter: 0.01 m; HotWaterConnectionDiameter: 0.01 m; ADACompliant: no; IndustryStandards: n/a; LEEDCredit: n/a; LowEmittingMaterial: no; MasterformatNumber: 01 52 19; MasterformatTitle: Sanitary Facilities; PercentageOfRecycledContent: n/a; ProductDocumentationLink: https://cdn.cloud.grohe.com/dimdraw/2000/2000/2090/2095/2095973/1500/2095973.jpg; ProductPageURL: https://www.grohe.co.uk/en_gb/euro-ceramic-mini-hand-rinse-basin-39327000.html; AccessibilityPerformance: n/a; ClassificationValue: Pr_40_20_96_15; CodePerformance: n/a; Color: White; Constituents: n/a; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; Features: Euro Ceramic Wallhung mini handrinse basin (37x18), Optional Proguard & HyperClean (00H), Vitreous china, Alpine White, 1 hole punched with overflow, 370 x 180 mm, 36 pcs per pallet; Finish: Ceramic; ManufacturerName: Grohe Limited; ModelReference: Euro Ceramic wallhung mini handrinse basin 37; ProductionYear: 2017; ReferencedStandard: n/a; ReplacementCost: n/a; Construction - OffsetFromLevel: 0.8 m
39327000_Grohe_EuroCeramicHandrinseBasin37 | 39327000 | 39327000_Grohe_EuroCeramicHandrinseBasin37 | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513992 | Appareils sanitaires | 2021_015 | Autre - Famille et type: 39327000; Famille: 39327000; Type: 39327000; ID du type: 39327000; SerialNumber: Please Record On Commissioning.; WarrantyStartDate: Please Record On Commissioning.; AssetIdentifier: Please Record On Commissioning.; BarCode: Please Record On Commissioning.; InstallationDate: Please Record On Commissioning.; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SINK; Exporter au format IFC sous: IfcSanitaryTerminalType; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 4; Type de système: Eaux Usées; Cotes - Volume: 0.00529304 m3; Surface: 0.183596 m2; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: -2.77485e-15 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: -2.77485e-15 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 716558; Nom: 39327000; Elévation par défaut: 0 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: Euro Ceramic wallhung mini handrinse basin 37; Fabricant: Grohe Limited; URL: www.grohe.com; Description: Euro Ceramic Wallhung mini handrinse basin (37x18), Optional Proguard & HyperClean (00H), Vitreous china, Alpine White, 1 hole punched with overflow, 370 x 180 mm, 36 pcs per pallet; Titre OmniClass: Sanitary Equipment; Numéro OmniClass: 23.45.05.00; Description de l'assemblage: Plumbing Fixtures; Code d'assemblage: D2010; Sous-projet: Famille : Appareils sanitaires : 39327000_Grohe_EuroCeramicHandrinseBasin37; Nom de la famille: 39327000_Grohe_EuroCeramicHandrinseBasin37; Nom du type: 39327000; Commentaires du type: 39327000; Type: Type prédéfini d'IFC: IfcPipeFittingType; Exporter le type au format IFC sous: IfcPipeFitting; Coût: 0.00; Grade: 2017; IfcExportAs: IfcPipeFitting; IfcExportType: IfcPipeFittingType; WFU: 0; HWFU: 4.5; CWFU: 4.5; AssetType: Fixed; CreatedBy: info-uk@grohe.com; CreatedOn: 2017-08-01T09:00:00; ExpectedLife: 0; ModelNumber: 39327000; Ecojoy: no; ClassificationName: Uniclass2015; Material: Ceramic; PrimaryMaterial: Ceramic, White; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: Euro Ceramic wallhung mini handrinse basin 37; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: info-uk@grohe.com; WarrantyGuarantorParts: info-uk@grohe.com; _Author: Ian Holmes; _AuthorizedBy: Kris Atkinson; _BimSpecGuid: 0; _BSBibleVersion: 14; _CreatedBy: www.bimstore.co.uk; _CurrentRevision: 0; _DistributedBy: www.bimstore.co.uk; BIMObjectName: PlumbingFixture_GroheLimited_EuroCeramicHandrinseBasin37_39327000_METRIC; NBSDescription: Ceramic sinks; NBSObjectName: Grohe Limited - Ceramic sinks; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/340; NominalDepth: 0 m; NominalHeight: 0 m; NominalLength: 0 m; ColdWaterConnectionDiameter: 0.01 m; HotWaterConnectionDiameter: 0.01 m; ADACompliant: no; IndustryStandards: n/a; LEEDCredit: n/a; LowEmittingMaterial: no; MasterformatNumber: 01 52 19; MasterformatTitle: Sanitary Facilities; PercentageOfRecycledContent: n/a; ProductDocumentationLink: https://cdn.cloud.grohe.com/dimdraw/2000/2000/2090/2095/2095973/1500/2095973.jpg; ProductPageURL: https://www.grohe.co.uk/en_gb/euro-ceramic-mini-hand-rinse-basin-39327000.html; AccessibilityPerformance: n/a; ClassificationValue: Pr_40_20_96_15; CodePerformance: n/a; Color: White; Constituents: n/a; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; Features: Euro Ceramic Wallhung mini handrinse basin (37x18), Optional Proguard & HyperClean (00H), Vitreous china, Alpine White, 1 hole punched with overflow, 370 x 180 mm, 36 pcs per pallet; Finish: Ceramic; ManufacturerName: Grohe Limited; ModelReference: Euro Ceramic wallhung mini handrinse basin 37; ProductionYear: 2017; ReferencedStandard: n/a; ReplacementCost: n/a; Construction - OffsetFromLevel: 0.8 m
Equipement de plomberie | Category | Equipement de plomberie | N0 FINI
SANISELF | Family | SANISELF | N0 FINI
SANISELF | Type | SANISELF | N0 FINI
SANISELF | SANISELF | SANISELF | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1335380 | Equipement de plomberie | 2021_015 | Autre - Famille et type: SANISELF; Famille: SANISELF; Type: SANISELF; ID du type: SANISELF; Paramètres IFC - Exporter au format IFC: 0; Exporter au format IFC sous: IfcFlowTerminal; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau chaude sanitaire,Eau froide sanitaire,Puissance; Nom du système: Eau Chaude Sanitaire 1,Eau Froide Sanitaire 1; Cotes - Volume: 0.00250382 m3; Surface: 0.0758592 m2; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Décalage par rapport à l'hôte: 0.3 m; Hôte: Niveau : N0 FINI; Élévation par rapport au niveau: 0.3 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1355934; Nom: SANISELF; Elévation par défaut: 0 m; Catégorie: Equipement de plomberie; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement de plomberie : SANISELF; Nom de la famille: SANISELF; Nom du type: SANISELF; Classification: 0
SANISELF | Instance | SANISELF | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1355934 | Equipement de plomberie | Famille : Equipement de plomberie : SANISELF | Autre - Nom de la famille: SANISELF; Données d'identification - Nom du type: SANISELF; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Classification: 0
Canalisation | Category | Canalisation | N0 FINI
Canalisation | Family | Canalisation | N0 FINI
4 x Standard | Type | Standard | N0 FINI
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1336595 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.6046 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0264582 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.1 L/s; Pression dynamique: 254.7 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 10053.2; Rugosité relative: 0.00289389; Etat du flux: 2; Facteur de frottement: 0.0349589; Vitesse: 0.7 m/s; Frottement: 563.65 Pa/m; Perte de pression: 316.5 Pa; Tronçon: 63; Contraintes - Arase inférieure à son extrémité aval: 0.591831 m; Arase supérieure à son extrémité amont: 0.613167 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.5946 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.5946 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.610399 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.610399 m; Arase supérieure à son extrémité aval: 0.613167 m; Arase inférieure à son extrémité amont: 0.591831 m; Elévation de l'axe à son extrémité aval: 0.602499 m; Elévation de l'axe à son extrémité amont: 0.602499 m; Inclinaison: 0.00%; Elévation du milieu: 0.602499 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.602499 m; Élévation centrale de départ: 0.602499 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.591831 m; Arase supérieure avec isolant à son extrémité aval: 0.613167 m; Arase inférieure avec isolant à son extrémité amont: 0.591831 m; Arase supérieure avec isolant à son extrémité amont: 0.613167 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 0.56146 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1336607 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.5021 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0941603 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 78; Contraintes - Arase inférieure à son extrémité aval: 0.489331 m; Arase supérieure à son extrémité amont: 0.510668 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.4921 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.492101 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.507898 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.507899 m; Arase supérieure à son extrémité aval: 0.510667 m; Arase inférieure à son extrémité amont: 0.489332 m; Elévation de l'axe à son extrémité aval: 0.499999 m; Elévation de l'axe à son extrémité amont: 0.5 m; Inclinaison: 0.00%; Elévation du milieu: 0.5 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.499999 m; Élévation centrale de départ: 0.5 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.489331 m; Arase supérieure avec isolant à son extrémité aval: 0.510667 m; Arase inférieure avec isolant à son extrémité amont: 0.489332 m; Arase supérieure avec isolant à son extrémité amont: 0.510668 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 1.99814 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1336642 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.591562 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00573801 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.1 L/s; Pression dynamique: 254.7 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 10053.2; Rugosité relative: 0.00289389; Etat du flux: 2; Facteur de frottement: 0.0349589; Vitesse: 0.7 m/s; Frottement: 563.65 Pa/m; Perte de pression: 68.6 Pa; Tronçon: 61; Contraintes - Arase inférieure à son extrémité aval: 0.578793 m; Arase supérieure à son extrémité amont: 0.600129 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.581562 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.581562 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.597361 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.597361 m; Arase supérieure à son extrémité aval: 0.600129 m; Arase inférieure à son extrémité amont: 0.578793 m; Elévation de l'axe à son extrémité aval: 0.589461 m; Elévation de l'axe à son extrémité amont: 0.589461 m; Inclinaison: 0.00%; Elévation du milieu: 0.589461 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.589461 m; Élévation centrale de départ: 0.589461 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.578793 m; Arase supérieure avec isolant à son extrémité aval: 0.600129 m; Arase inférieure avec isolant à son extrémité amont: 0.578793 m; Arase supérieure avec isolant à son extrémité amont: 0.600129 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 0.121764 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1336662 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.586561 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00565485 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.1 L/s; Pression dynamique: 254.7 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 10053.2; Rugosité relative: 0.00289389; Etat du flux: 2; Facteur de frottement: 0.0349589; Vitesse: 0.7 m/s; Frottement: 563.65 Pa/m; Perte de pression: 67.6 Pa; Tronçon: 62; Contraintes - Arase inférieure à son extrémité aval: 0.573792 m; Arase supérieure à son extrémité amont: 0.595128 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.576561 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.576561 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.59236 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.59236 m; Arase supérieure à son extrémité aval: 0.595128 m; Arase inférieure à son extrémité amont: 0.573792 m; Elévation de l'axe à son extrémité aval: 0.58446 m; Elévation de l'axe à son extrémité amont: 0.58446 m; Inclinaison: 0.00%; Elévation du milieu: 0.58446 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.58446 m; Élévation centrale de départ: 0.58446 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.573792 m; Arase supérieure avec isolant à son extrémité aval: 0.595128 m; Arase inférieure avec isolant à son extrémité amont: 0.573792 m; Arase supérieure avec isolant à son extrémité amont: 0.595128 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 0.12 m
