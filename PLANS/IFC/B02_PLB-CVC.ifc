Properties of the parts of a building model (IFC4), part 10 of 10

# IfcBuildingElementProxy (115)
Name | Elément, Type | Elément, Nom | Calque | Value = Authoring Tool Id | Autre, Catégorie | Autre, Nom de la famille | Type prédéfini d'IFC | Exporter au format IFC sous | Données d'identification, Sous-projet | Données d'identification, Nom du type | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | Génie climatique, Classification du système | Nom du système | Type de système | GEM_ROP_LIGNE CCTP | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Epaisseur d'isolation (m) | Taille globale | Taille | Longueur (m)
Unknown | Ligne d'axe | Unknown | N0 FINI | 1377991 | Raccords de canalisation | Té - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm-ø25 mm-ø25 mm | ø25 mm-ø25 mm-ø25 mm | Autre - Rayon extérieur du raccord: 0.0167 m; Libellé de centre à extrémité: 0.038 m; Angle 1: 89.9889 deg; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 2.7 m; Cotes - Rayon nominal: 0.0125 m; Diamètre nominal: 0.025 m; Diamètre extérieur du raccord: 0.0334 m; Taille de la coche: 0.01336 m; Centre à extrémité: 0.038 m; Angle: 89.9889 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1378945 | Raccords de canalisation | Té - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø100 mm-ø100 mm-ø100 mm | ø100 mm-ø100 mm-ø100 mm | Autre - Rayon extérieur du raccord: 0.05715 m; Libellé de centre à extrémité: 0.105 m; Angle 1: 89.9996 deg; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.0587314 m; Cotes - Rayon nominal: 0.05 m; Diamètre nominal: 0.1 m; Diamètre extérieur du raccord: 0.1143 m; Taille de la coche: 0.04572 m; Centre à extrémité: 0.105 m; Angle: 89.9996 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1379189 | Raccords de canalisation | AliaxisFR_Hometech_ExternalReducer_FR | TRANSITION | IfcPipeFittingType | 2021_015 | Variable | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø100 mm-ø40 mm | ø100 mm-ø40 mm | Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.0902254 m; Graphismes - Utiliser l'échelle d'annotations: yes; Autre - IsCustom: yes; Not Flipped: yes; Flipped: no; Socket Flipped: no; Socket Not Flipped: no; Données d'identification - Article Nr: Custom Fitting; Cotes - D2: 0.005 m; L1: 0.036 m; L2: 0.057 m; D: 0.093 m; D3: 0 m; D4: 0 m; Pipe Outer Diameter 1: 0.1 m; Pipe Outer Diameter 2: 0.04 m; Connector Diameter 2: 0.04 m; Connector Diameter 1: 0.1 m; Pipe Outer Diameter 3: 0.02 m; L3: 0.027 m; Connector 1: 0.1 m; Connector 2: 0.04 m; L5: 0.03 m; Construction - Eccentric: no; Socket Visibility: no; Texte - Lookup Table Name 1: Hometech_ExternalReducer
Unknown | Ligne d'axe | Unknown | N0 FINI | 1379943 | Raccords de canalisation | Té - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø100 mm-ø100 mm-ø100 mm | ø100 mm-ø100 mm-ø100 mm | Autre - Rayon extérieur du raccord: 0.05715 m; Libellé de centre à extrémité: 0.105 m; Angle 1: 90 deg; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.0709787 m; Cotes - Rayon nominal: 0.05 m; Diamètre nominal: 0.1 m; Diamètre extérieur du raccord: 0.1143 m; Taille de la coche: 0.04572 m; Centre à extrémité: 0.105 m; Angle: 90 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1528550 | Raccords de canalisation | Coude - Générique | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 4 | Eaux Usées |  |  |  |  |  | 0 | ø40 mm-ø40 mm | ø40 mm-ø40 mm | Autre - Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.038 m; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.491037 m; Cotes - Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 90 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1528552 | Raccords de canalisation | Transformation - Générique | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 4 | Eaux Usées |  |  |  |  |  | 0 | ø40 mm-ø40 mm | ø40 mm-ø40 mm | 0.064 | Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.453151 m; Graphismes - Utiliser l'échelle d'annotations: yes; Autre - Rayon extérieur du raccord 1: 0.02415 m; Rayon extérieur du raccord 2: 0.02415 m; Diamètre nominal max. 12: 0.04 m; Décalage de la largeur: 3.05933 m; Décalage de la hauteur: 3.048 m; Visibilité 1: yes; Visibilité 2: no; Visibilité 3: no; Cotes - Hauteur de décalage: 20.0000 mm; Largeur de décalage: 31.3304 mm; Rayon nominal 1: 0.02 m; Diamètre nominal 1: 0.04 m; Diamètre extérieur du raccord 1: 0.0483 m; Taille de la coche 1: 0.01932 m; Rayon nominal 2: 0.02 m; Diamètre nominal 2: 0.04 m; Diamètre extérieur du raccord 2: 0.0483 m; Taille de la coche 2: 0.01932 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1528711 | Raccords de canalisation | Coude - Générique | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées |  |  |  |  |  | 0 | ø40 mm-ø40 mm | ø40 mm-ø40 mm | Autre - Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.038 m; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.491037 m; Cotes - Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 90 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1528713 | Raccords de canalisation | Transformation - Générique | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées |  |  |  |  |  | 0 | ø40 mm-ø40 mm | ø40 mm-ø40 mm | 0.064 | Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.453152 m; Graphismes - Utiliser l'échelle d'annotations: yes; Autre - Rayon extérieur du raccord 1: 0.02415 m; Rayon extérieur du raccord 2: 0.02415 m; Diamètre nominal max. 12: 0.04 m; Décalage de la largeur: 3.05933 m; Décalage de la hauteur: 3.048 m; Visibilité 1: yes; Visibilité 2: no; Visibilité 3: no; Cotes - Hauteur de décalage: 20.0000 mm; Largeur de décalage: 31.3301 mm; Rayon nominal 1: 0.02 m; Diamètre nominal 1: 0.04 m; Diamètre extérieur du raccord 1: 0.0483 m; Taille de la coche 1: 0.01932 m; Rayon nominal 2: 0.02 m; Diamètre nominal 2: 0.04 m; Diamètre extérieur du raccord 2: 0.0483 m; Taille de la coche 2: 0.01932 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1511660 | Gaine | Gaine circulaire | RIGIDSEGMENT | IfcDuctSegmentType | 2021_015 | Té / Coude segmenté | Phases | 1 | Existant | Paramètres des phases | 12589 | Reprise | Génie climatique Reprise 1 | Reprise |  |  |  |  |  | 0 | ø125 mm | ø125 | 1.92945 | Génie climatique - Surface: 0.757693 m2; Verrouillage de la taille: no; Contraintes - Arase inférieure à son extrémité aval: 2.59369 m; Arase supérieure à son extrémité amont: 2.76248 m; Inclinaison: 2.27%; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: 2.65617 m; Elévation de l'axe à son extrémité amont: 2.7 m; Génie climatique - Débit - Débit supplémentaire: 0.0 m³/h; Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Nombre de Reynolds: 0; Rugosité relative: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Diamètre hydraulique: 0.125 m; Cotes - Diamètre: 0.125 m; Revêtement - Taille libre: ø125 mm; Epaisseur du revêtement: 0 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1511696 | Gaine | Gaine circulaire |  |  | 2021_015 | Té / Coude segmenté | Phases | 1 | Existant | Paramètres des phases | 12589 | Reprise | Génie climatique Reprise 1 | Reprise |  |  |  |  |  | 0 | ø125 mm | ø125 | 0.189 | Génie climatique - Surface: 0.0742201 m2; Verrouillage de la taille: no; Contraintes - Arase inférieure à son extrémité aval: 2.6415 m; Arase supérieure à son extrémité amont: 2.7665 m; Inclinaison: 0.00%; Elévation du milieu: 2.704 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Génie climatique - Débit - Débit supplémentaire: 0.0 m³/h; Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Nombre de Reynolds: 0; Rugosité relative: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Diamètre hydraulique: 0.125 m; Cotes - Diamètre: 0.125 m; Revêtement - Taille libre: ø125 mm; Epaisseur du revêtement: 0 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1512724 | Gaine | Gaine circulaire | RIGIDSEGMENT | IfcDuctSegmentType | 2021_015 | Té / Coude segmenté | Phases | 1 | Existant | Paramètres des phases | 12589 | Reprise | Génie climatique Reprise 2 | Reprise |  |  |  |  |  | 0 | ø150 mm | ø150 | 4.50477 | Génie climatique - Surface: 2.12282 m2; Verrouillage de la taille: no; Contraintes - Arase inférieure à son extrémité aval: 2.629 m; Arase supérieure à son extrémité amont: 2.779 m; Inclinaison: 0.00%; Elévation du milieu: 2.704 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Génie climatique - Débit - Débit supplémentaire: 0.0 m³/h; Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Nombre de Reynolds: 0; Rugosité relative: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Diamètre hydraulique: 0.15 m; Cotes - Diamètre: 0.15 m; Revêtement - Taille libre: ø150 mm; Epaisseur du revêtement: 0 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1513063 | Gaine | Gaine circulaire | RIGIDSEGMENT | IfcDuctSegmentType | 2021_015 | Té / Coude segmenté | Phases | 1 | Existant | Paramètres des phases | 12589 | Reprise | Génie climatique Reprise 2 | Reprise |  |  |  |  |  | 0 | ø80 mm | ø80 | 0.596 | Génie climatique - Surface: 0.149791 m2; Verrouillage de la taille: no; Contraintes - Arase inférieure à son extrémité aval: 2.56 m; Arase supérieure à son extrémité amont: 2.64 m; Inclinaison: 0.00%; Elévation du milieu: 2.6 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Génie climatique - Débit - Débit supplémentaire: 0.0 m³/h; Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Nombre de Reynolds: 0; Rugosité relative: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Diamètre hydraulique: 0.08 m; Cotes - Diamètre: 0.08 m; Revêtement - Taille libre: ø80 mm; Epaisseur du revêtement: 0 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1513065 | Gaine | Gaine circulaire | RIGIDSEGMENT | IfcDuctSegmentType | 2021_015 | Té / Coude segmenté | Phases | 1 | Existant | Paramètres des phases | 12589 | Reprise | Génie climatique Reprise 2 | Reprise |  |  |  |  |  | 0 | ø80 mm | ø80 | 1.457 | Génie climatique - Surface: 0.366184 m2; Verrouillage de la taille: no; Contraintes - Arase inférieure à son extrémité aval: 2.56 m; Arase supérieure à son extrémité amont: 2.64 m; Inclinaison: 0.00%; Elévation du milieu: 2.6 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Génie climatique - Débit - Débit supplémentaire: 0.0 m³/h; Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Nombre de Reynolds: 0; Rugosité relative: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Diamètre hydraulique: 0.08 m; Cotes - Diamètre: 0.08 m; Revêtement - Taille libre: ø80 mm; Epaisseur du revêtement: 0 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1513067 | Gaine | Gaine circulaire | RIGIDSEGMENT | IfcDuctSegmentType | 2021_015 | Té / Coude segmenté | Phases | 1 | Existant | Paramètres des phases | 12589 | Reprise | Génie climatique Reprise 2 | Reprise |  |  |  |  |  | 0 | ø80 mm | ø80 | 1.244 | Génie climatique - Surface: 0.312651 m2; Verrouillage de la taille: no; Contraintes - Arase inférieure à son extrémité aval: 2.56 m; Arase supérieure à son extrémité amont: 2.64 m; Inclinaison: 0.00%; Elévation du milieu: 2.6 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Génie climatique - Débit - Débit supplémentaire: 0.0 m³/h; Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Nombre de Reynolds: 0; Rugosité relative: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Diamètre hydraulique: 0.08 m; Cotes - Diamètre: 0.08 m; Revêtement - Taille libre: ø80 mm; Epaisseur du revêtement: 0 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1513069 | Gaine | Gaine circulaire | RIGIDSEGMENT | IfcDuctSegmentType | 2021_015 | Té / Coude segmenté | Phases | 1 | Existant | Paramètres des phases | 12589 | Reprise | Génie climatique Reprise 3 | Reprise |  |  |  |  |  | 0 | ø80 mm | ø80 | 1.088 | Génie climatique - Surface: 0.273444 m2; Verrouillage de la taille: no; Contraintes - Arase inférieure à son extrémité aval: 2.56 m; Arase supérieure à son extrémité amont: 2.64 m; Inclinaison: 0.00%; Elévation du milieu: 2.6 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Génie climatique - Débit - Débit supplémentaire: 0.0 m³/h; Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Nombre de Reynolds: 0; Rugosité relative: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Diamètre hydraulique: 0.08 m; Cotes - Diamètre: 0.08 m; Revêtement - Taille libre: ø80 mm; Epaisseur du revêtement: 0 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1513075 | Gaine | Gaine circulaire | RIGIDSEGMENT | IfcDuctSegmentType | 2021_015 | Té / Coude segmenté | Phases | 1 | Existant | Paramètres des phases | 12589 | Reprise | Génie climatique Reprise 2 | Reprise |  |  |  |  |  | 0 | ø150 mm | ø150 | 2.699 | Génie climatique - Surface: 1.27187 m2; Verrouillage de la taille: no; Contraintes - Arase inférieure à son extrémité aval: 2.525 m; Arase supérieure à son extrémité amont: 2.675 m; Inclinaison: 0.00%; Elévation du milieu: 2.6 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Génie climatique - Débit - Débit supplémentaire: 0.0 m³/h; Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Nombre de Reynolds: 0; Rugosité relative: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Diamètre hydraulique: 0.15 m; Cotes - Diamètre: 0.15 m; Revêtement - Taille libre: ø150 mm; Epaisseur du revêtement: 0 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1513292 | Gaine | Gaine circulaire | RIGIDSEGMENT | IfcDuctSegmentType | 2021_015 | Té / Coude segmenté | Phases | 1 | Existant | Paramètres des phases | 12589 | Reprise | Génie climatique Reprise 2 | Reprise |  |  |  |  |  | 0 | ø150 mm | ø150 | 0.966 | Génie climatique - Surface: 0.455217 m2; Verrouillage de la taille: no; Contraintes - Arase inférieure à son extrémité aval: 2.525 m; Arase supérieure à son extrémité amont: 2.675 m; Inclinaison: 0.00%; Elévation du milieu: 2.6 m; Justification verticale: 1; Justification horizontale: 1; Niveau de référence: N0 FINI; Génie climatique - Débit - Débit supplémentaire: 0.0 m³/h; Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Nombre de Reynolds: 0; Rugosité relative: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Diamètre hydraulique: 0.15 m; Cotes - Diamètre: 0.15 m; Revêtement - Taille libre: ø150 mm; Epaisseur du revêtement: 0 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1513327 | Gaine | Gaine circulaire | RIGIDSEGMENT | IfcDuctSegmentType | 2021_015 | Té / Coude segmenté | Phases | 1 | Existant | Paramètres des phases | 12589 | Reprise | Génie climatique Reprise 2 | Reprise |  |  |  |  |  | 0 | ø150 mm | ø150 | 3.15887 | Génie climatique - Surface: 1.48858 m2; Verrouillage de la taille: no; Contraintes - Arase inférieure à son extrémité aval: 2.55502 m; Arase supérieure à son extrémité amont: 2.77898 m; Inclinaison: 2.34%; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: 2.63 m; Elévation de l'axe à son extrémité amont: 2.704 m; Génie climatique - Débit - Débit supplémentaire: 0.0 m³/h; Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Nombre de Reynolds: 0; Rugosité relative: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Diamètre hydraulique: 0.15 m; Cotes - Diamètre: 0.15 m; Revêtement - Taille libre: ø150 mm; Epaisseur du revêtement: 0 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1513393 | Gaine | Gaine circulaire | RIGIDSEGMENT | IfcDuctSegmentType | 2021_015 | Té / Coude segmenté | Phases | 1 | Existant | Paramètres des phases | 12589 | Reprise | Génie climatique Reprise 2 | Reprise |  |  |  |  |  | 0 | ø150 mm | ø150 | 2.56991 | Génie climatique - Surface: 1.21104 m2; Verrouillage de la taille: no; Contraintes - Arase inférieure à son extrémité aval: 2.555 m; Arase supérieure à son extrémité amont: 2.705 m; Inclinaison: 0.00%; Elévation du milieu: 2.63 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Génie climatique - Débit - Débit supplémentaire: 0.0 m³/h; Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Nombre de Reynolds: 0; Rugosité relative: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Diamètre hydraulique: 0.15 m; Cotes - Diamètre: 0.15 m; Revêtement - Taille libre: ø150 mm; Epaisseur du revêtement: 0 m
Système de canalisation | Eau Froide Sanitaire | Système de canalisation | <NoLevel> | 1335763 | Système de canalisation |  |  |  | Sous-projet 1 |  |  |  |  |  |  |  | Eau Froide Sanitaire 1 | Génie climatique - Débit - Débit: 0.4 L/s; Autre - Famille et type: Eau Froide Sanitaire; Famille: Eau Froide Sanitaire; Type: Eau Froide Sanitaire; ID du type: Eau Froide Sanitaire; Génie climatique - Nombre d'éléments: 7; Equipement du système: Default; Débit par appareil: 0; Volume: 0.00936939 m3; Type de Revit - Id: 621825; Nom: Eau Froide Sanitaire; Catégorie: Système de canalisation; Sous-projet: Types de système de canalisation; Nom de la famille: Système de canalisation; Nom du type: Eau Froide Sanitaire; Symbole de descente à deux lignes: 11; Symbole de montée à deux lignes: 1; Symbole de descente à ligne unique: 13; Symbole de montée à ligne unique: 1; Symbole de montée de té à ligne unique: 1; Symbole de descente de té à ligne unique: 15; Calculs: -1; Méthode de conversion de débit: 0; Classification du système: Eau froide sanitaire; Type de fluide: Eau; Température du fluide: 16 °C; Viscosité dynamique du fluide: 0.00112 Pa-s; Densité du fluide: 998.9114 kg/m³
Système de canalisation | Eau Froide Sanitaire | Système de canalisation | <NoLevel> | 1354624 | Système de canalisation |  |  |  | Sous-projet 1 |  |  |  |  |  |  |  | Eau Froide Sanitaire 3 | Autre - Famille et type: Eau Froide Sanitaire; Famille: Eau Froide Sanitaire; Type: Eau Froide Sanitaire; ID du type: Eau Froide Sanitaire; Génie climatique - Nombre d'éléments: 1; Débit par appareil: 0; Volume: 0.000151524 m3; Type de Revit - Id: 621825; Nom: Eau Froide Sanitaire; Catégorie: Système de canalisation; Sous-projet: Types de système de canalisation; Nom de la famille: Système de canalisation; Nom du type: Eau Froide Sanitaire; Symbole de descente à deux lignes: 11; Symbole de montée à deux lignes: 1; Symbole de descente à ligne unique: 13; Symbole de montée à ligne unique: 1; Symbole de montée de té à ligne unique: 1; Symbole de descente de té à ligne unique: 15; Calculs: -1; Méthode de conversion de débit: 0; Classification du système: Eau froide sanitaire; Type de fluide: Eau; Température du fluide: 16 °C; Viscosité dynamique du fluide: 0.00112 Pa-s; Densité du fluide: 998.9114 kg/m³
Système de canalisation | Eau Froide Sanitaire | Système de canalisation | <NoLevel> | 1354856 | Système de canalisation |  |  |  | Sous-projet 1 |  |  |  |  |  |  |  | Eau Froide Sanitaire 5 | Autre - Famille et type: Eau Froide Sanitaire; Famille: Eau Froide Sanitaire; Type: Eau Froide Sanitaire; ID du type: Eau Froide Sanitaire; Génie climatique - Nombre d'éléments: 1; Débit par appareil: 0; Volume: 0.000887095 m3; Type de Revit - Id: 621825; Nom: Eau Froide Sanitaire; Catégorie: Système de canalisation; Sous-projet: Types de système de canalisation; Nom de la famille: Système de canalisation; Nom du type: Eau Froide Sanitaire; Symbole de descente à deux lignes: 11; Symbole de montée à deux lignes: 1; Symbole de descente à ligne unique: 13; Symbole de montée à ligne unique: 1; Symbole de montée de té à ligne unique: 1; Symbole de descente de té à ligne unique: 15; Calculs: -1; Méthode de conversion de débit: 0; Classification du système: Eau froide sanitaire; Type de fluide: Eau; Température du fluide: 16 °C; Viscosité dynamique du fluide: 0.00112 Pa-s; Densité du fluide: 998.9114 kg/m³
Système de canalisation | Eaux Usées | Système de canalisation | <NoLevel> | 1336771 | Système de canalisation |  |  |  | Sous-projet 1 |  |  |  |  |  |  |  | Eaux Usées 1 | Autre - Famille et type: Eaux Usées; Famille: Eaux Usées; Type: Eaux Usées; ID du type: Eaux Usées; Génie climatique - Nombre d'éléments: 3; Débit par appareil: 0; Type de Revit - Id: 621823; Nom: Eaux Usées; Catégorie: Système de canalisation; Sous-projet: Types de système de canalisation; Nom de la famille: Système de canalisation; Nom du type: Eaux Usées; Symbole de descente à deux lignes: 11; Symbole de montée à deux lignes: 1; Symbole de descente à ligne unique: 13; Symbole de montée à ligne unique: 1; Symbole de montée de té à ligne unique: 1; Symbole de descente de té à ligne unique: 15; Calculs: 1; Classification du système: Sanitaire
Système de canalisation | Eaux Usées | Système de canalisation | <NoLevel> | 1343634 | Système de canalisation |  |  |  | Sous-projet 1 |  |  |  |  |  |  |  | Eaux Usées 3 | Autre - Famille et type: Eaux Usées; Famille: Eaux Usées; Type: Eaux Usées; ID du type: Eaux Usées; Génie climatique - Nombre d'éléments: 2; Débit par appareil: 0; Type de Revit - Id: 621823; Nom: Eaux Usées; Catégorie: Système de canalisation; Sous-projet: Types de système de canalisation; Nom de la famille: Système de canalisation; Nom du type: Eaux Usées; Symbole de descente à deux lignes: 11; Symbole de montée à deux lignes: 1; Symbole de descente à ligne unique: 13; Symbole de montée à ligne unique: 1; Symbole de montée de té à ligne unique: 1; Symbole de descente de té à ligne unique: 15; Calculs: 1; Classification du système: Sanitaire
Système de canalisation | Eaux Usées | Système de canalisation | <NoLevel> | 1378428 | Système de canalisation |  |  |  | 2021_015 |  |  |  |  |  |  |  | Eaux Usées 2 | Autre - Famille et type: Eaux Usées; Famille: Eaux Usées; Type: Eaux Usées; ID du type: Eaux Usées; Génie climatique - Nombre d'éléments: 1; Débit par appareil: 0; Type de Revit - Id: 621823; Nom: Eaux Usées; Catégorie: Système de canalisation; Sous-projet: Types de système de canalisation; Nom de la famille: Système de canalisation; Nom du type: Eaux Usées; Symbole de descente à deux lignes: 11; Symbole de montée à deux lignes: 1; Symbole de descente à ligne unique: 13; Symbole de montée à ligne unique: 1; Symbole de montée de té à ligne unique: 1; Symbole de descente de té à ligne unique: 15; Calculs: 1; Classification du système: Sanitaire
Système de canalisation | Eaux Usées | Système de canalisation | <NoLevel> | 1379465 | Système de canalisation |  |  |  | 2021_015 |  |  |  |  |  |  |  | Eaux Usées 4 | Autre - Famille et type: Eaux Usées; Famille: Eaux Usées; Type: Eaux Usées; ID du type: Eaux Usées; Génie climatique - Nombre d'éléments: 1; Débit par appareil: 0; Type de Revit - Id: 621823; Nom: Eaux Usées; Catégorie: Système de canalisation; Sous-projet: Types de système de canalisation; Nom de la famille: Système de canalisation; Nom du type: Eaux Usées; Symbole de descente à deux lignes: 11; Symbole de montée à deux lignes: 1; Symbole de descente à ligne unique: 13; Symbole de montée à ligne unique: 1; Symbole de montée de té à ligne unique: 1; Symbole de descente de té à ligne unique: 15; Calculs: 1; Classification du système: Sanitaire
Système de canalisation | Eau Chaude Sanitaire | Système de canalisation | <NoLevel> | 1380048 | Système de canalisation |  |  |  | 2021_015 |  |  |  |  |  |  |  | Eau Chaude Sanitaire 1 | Autre - Famille et type: Eau Chaude Sanitaire; Famille: Eau Chaude Sanitaire; Type: Eau Chaude Sanitaire; ID du type: Eau Chaude Sanitaire; Génie climatique - Nombre d'éléments: 2; Débit par appareil: 0; Volume: 0.0000351497 m3; Type de Revit - Id: 621824; Nom: Eau Chaude Sanitaire; Catégorie: Système de canalisation; Sous-projet: Types de système de canalisation; Nom de la famille: Système de canalisation; Nom du type: Eau Chaude Sanitaire; Symbole de descente à deux lignes: 11; Symbole de montée à deux lignes: 1; Symbole de descente à ligne unique: 13; Symbole de montée à ligne unique: 1; Symbole de montée de té à ligne unique: 1; Symbole de descente de té à ligne unique: 15; Calculs: -1; Méthode de conversion de débit: 1; Classification du système: Eau chaude sanitaire; Type de fluide: Eau; Température du fluide: 60 °C; Viscosité dynamique du fluide: 0.00047 Pa-s; Densité du fluide: 983.2133 kg/m³
Système de gaines | Reprise | Système de gaines | <NoLevel> | 1511590 | Systèmes de gaines |  |  |  | 2021_015 |  |  |  |  |  |  |  | Génie climatique Reprise 1 | Génie climatique - Débit - Débit: 0.0 m³/h; Autre - Famille et type: Reprise; Famille: Reprise; Type: Reprise; ID du type: Reprise; Génie climatique - Nombre d'éléments: 2; Pression statique: 0.0 Pa; Type de Revit - Id: 621817; Nom: Reprise; Catégorie: Systèmes de gaines; Sous-projet: Types de système de gaines; Nom de la famille: Système de gaines; Nom du type: Reprise; Calculs: -1; Classification du système: Reprise; Symbole de montée/descente: 4; Revizto - Mechanical: yes
Système de gaines | Reprise | Système de gaines | <NoLevel> | 1512628 | Systèmes de gaines |  |  |  | 2021_015 |  |  |  |  |  |  |  | Génie climatique Reprise 2 | Génie climatique - Débit - Débit: 0.0 m³/h; Autre - Famille et type: Reprise; Famille: Reprise; Type: Reprise; ID du type: Reprise; Génie climatique - Nombre d'éléments: 3; Equipement du système: HYGROCOSY BC FLEX; Type de Revit - Id: 621817; Nom: Reprise; Catégorie: Systèmes de gaines; Sous-projet: Types de système de gaines; Nom de la famille: Système de gaines; Nom du type: Reprise; Calculs: -1; Classification du système: Reprise; Symbole de montée/descente: 4; Revizto - Mechanical: yes
Système de gaines | Reprise | Système de gaines | <NoLevel> | 1513725 | Systèmes de gaines |  |  |  | 2021_015 |  |  |  |  |  |  |  | Génie climatique Reprise 3 | Génie climatique - Débit - Débit: 0.0 m³/h; Autre - Famille et type: Reprise; Famille: Reprise; Type: Reprise; ID du type: Reprise; Génie climatique - Nombre d'éléments: 0; Pression statique: 0.0 Pa; Type de Revit - Id: 621817; Nom: Reprise; Catégorie: Systèmes de gaines; Sous-projet: Types de système de gaines; Nom de la famille: Système de gaines; Nom du type: Reprise; Calculs: -1; Classification du système: Reprise; Symbole de montée/descente: 4; Revizto - Mechanical: yes
Unknown | Ligne d'axe | Unknown | N0 | 1353507 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 5.97709 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.281664 m2; Contraintes - Arase inférieure à son extrémité aval: 0.089332 m; Arase supérieure à son extrémité amont: 0.110668 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0921006 m; Inclinaison: 0.00%; Elévation du milieu: 0.1 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 | 1353516 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 0.273766 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0129009 m2; Contraintes - Arase inférieure à son extrémité aval: 0.089332 m; Arase supérieure à son extrémité amont: 0.110668 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0921006 m; Inclinaison: 0.00%; Elévation du milieu: 0.1 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 | 1353675 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 0.307089 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0144712 m2; Contraintes - Arase inférieure à son extrémité aval: 0.689332 m; Arase supérieure à son extrémité amont: 0.710668 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.692101 m; Inclinaison: 0.00%; Elévation du milieu: 0.7 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 | 1353926 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 0.41242 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0194348 m2; Contraintes - Arase inférieure à son extrémité aval: 0.115909 m; Arase supérieure à son extrémité amont: 0.528329 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.115909 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0; Elévation de l'axe à son extrémité aval: 0.115909 m; Elévation de l'axe à son extrémité amont: 0.528329 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 | 1354445 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 0.109762 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00517241 m2; Contraintes - Arase inférieure à son extrémité aval: 0.574329 m; Arase supérieure à son extrémité amont: 0.684091 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.574329 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0; Elévation de l'axe à son extrémité aval: 0.574329 m; Elévation de l'axe à son extrémité amont: 0.684091 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 | 1354623 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 3 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø40 mm | ø40 mm | 0.115364 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0144971 m2; Contraintes - Arase inférieure à son extrémité aval: 0.680636 m; Arase supérieure à son extrémité amont: 0.796 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.680636 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0; Elévation de l'axe à son extrémité aval: 0.680636 m; Elévation de l'axe à son extrémité amont: 0.796 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 | 1354855 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 5 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø40 mm | ø40 mm | 0.574 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.072131 m2; Contraintes - Arase inférieure à son extrémité aval: -0.00605686 m; Arase supérieure à son extrémité amont: 0.568059 m; Elévation du fond (fil d'eau) à son extrémité aval: -0.00604791 m; Inclinaison: 41136.52%; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0; Elévation de l'axe à son extrémité aval: -0.0059982 m; Elévation de l'axe à son extrémité amont: 0.568 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 | 1378683 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø40 mm | ø40 mm | 1.19952 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.150736 m2; Contraintes - Arase inférieure à son extrémité aval: 0.0642665 m; Arase supérieure à son extrémité amont: 0.112526 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0679495 m; Inclinaison: 0.00%; Elévation du milieu: 0.0883965 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Génie climatique - Débit - Débit par appareil: 0
Unknown | Ligne d'axe | Unknown | N0 | 1379137 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø40 mm | ø40 mm | 1.23015 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.154585 m2; Contraintes - Arase inférieure à son extrémité aval: 0.0845148 m; Arase supérieure à son extrémité amont: 0.132775 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0881978 m; Inclinaison: 0.00%; Elévation du milieu: 0.108645 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Génie climatique - Débit - Débit par appareil: 0
Unknown | Ligne d'axe | Unknown | N0 | 1379210 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 4 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø40 mm | ø40 mm | 0.164362 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0206544 m2; Contraintes - Arase inférieure à son extrémité aval: 0.0843722 m; Arase supérieure à son extrémité amont: 0.132632 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0880552 m; Inclinaison: 0.00%; Elévation du milieu: 0.108502 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Génie climatique - Débit - Débit par appareil: 0
Unknown | Ligne d'axe | Unknown | N0 | 1379236 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 4 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø40 mm | ø40 mm | 2.3969 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.301203 m2; Contraintes - Arase inférieure à son extrémité aval: 0.0843722 m; Arase supérieure à son extrémité amont: 0.132632 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0880552 m; Inclinaison: 0.00%; Elévation du milieu: 0.108502 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Génie climatique - Débit - Débit par appareil: 0
Unknown | Ligne d'axe | Unknown | N0 | 1379820 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 4 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø40 mm | ø40 mm | 0.274655 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0345142 m2; Contraintes - Arase inférieure à son extrémité aval: 0.144521 m; Arase supérieure à son extrémité amont: 0.422087 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.144806 m; Inclinaison: 1288.41%; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0; Elévation de l'axe à son extrémité aval: 0.146388 m; Elévation de l'axe à son extrémité amont: 0.42022 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Génie climatique - Débit - Débit par appareil: 0
Unknown | Ligne d'axe | Unknown | N0 | 1379931 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø40 mm | ø40 mm | 0.274529 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0344983 m2; Contraintes - Arase inférieure à son extrémité aval: 0.144653 m; Arase supérieure à son extrémité amont: 0.422104 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.14494 m; Inclinaison: 1282.04%; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0; Elévation de l'axe à son extrémité aval: 0.14653 m; Elévation de l'axe à son extrémité amont: 0.420227 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Génie climatique - Débit - Débit par appareil: 0
Unknown | Ligne d'axe | Unknown | N0 | 1529358 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées |  |  |  |  |  | 0 | ø40 mm | ø40 mm | 0.0501747 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00630514 m2; Contraintes - Arase inférieure à son extrémité aval: 0.496907 m; Arase supérieure à son extrémité amont: 0.545167 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.50059 m; Inclinaison: 0.00%; Elévation du milieu: 0.521037 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Génie climatique - Débit - Débit par appareil: 0
Unknown | Ligne d'axe | Unknown | N0 | 1353936 | Raccords de canalisation | Coude - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø15 mm | ø15 mm-ø15 mm | Autre - Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.015909 m; Rayon du centre: 0.015909 m; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.1 m; Cotes - Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 90 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 | 1353938 | Raccords de canalisation | Coude - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø15 mm | ø15 mm-ø15 mm | Autre - Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.015909 m; Rayon du centre: 0.015909 m; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.1 m; Cotes - Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 90 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 | 1354161 | Raccords de canalisation | Coude - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø15 mm | ø15 mm-ø15 mm | Autre - Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.015909 m; Rayon du centre: 0.015909 m; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.7 m; Cotes - Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 90 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 | 1354167 | Raccords de canalisation | Té - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø15 mm-ø15 mm | ø15 mm-ø15 mm-ø15 mm | Autre - Rayon extérieur du raccord: 0.01065 m; Libellé de centre à extrémité: 0.025 m; Angle 1: 90 deg; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.7 m; Cotes - Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.0213 m; Taille de la coche: 0.00852 m; Centre à extrémité: 0.025 m; Angle: 90 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 | 1354252 | Raccords de canalisation | RACCORD REDUCTEUR 15-10 | TRANSITION | IfcPipeFittingType | 2021_015 | RACCORD REDUCTEUR 15-10 | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø10 mm | ø15 mm-ø10 mm | Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.731 m; Graphismes - Utiliser l'échelle d'annotations: yes; Génie climatique - Débit - Perte de pression: 0.0 Pa
Unknown | Ligne d'axe | Unknown | N0 | 1354265 | Raccords de canalisation | RACCORD REDUCTEUR 15-10 | TRANSITION | IfcPipeFittingType | 2021_015 | RACCORD REDUCTEUR 15-10 | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø10 mm | ø15 mm-ø10 mm | Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.669 m; Graphismes - Utiliser l'échelle d'annotations: yes; Génie climatique - Débit - Perte de pression: 0.0 Pa
Unknown | Ligne d'axe | Unknown | N0 | 1378195 | Raccords de canalisation | Té - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm-ø25 mm-ø25 mm | ø25 mm-ø25 mm-ø25 mm | Autre - Rayon extérieur du raccord: 0.0167 m; Libellé de centre à extrémité: 0.038 m; Angle 1: 90 deg; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.1 m; Cotes - Rayon nominal: 0.0125 m; Diamètre nominal: 0.025 m; Diamètre extérieur du raccord: 0.0334 m; Taille de la coche: 0.01336 m; Centre à extrémité: 0.038 m; Angle: 90 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 | 1378202 | Raccords de canalisation | Transformation - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm-ø15 mm | ø25 mm-ø15 mm | 0.051 | Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.1 m; Graphismes - Utiliser l'échelle d'annotations: yes; Autre - Rayon extérieur du raccord 1: 0.0167 m; Rayon extérieur du raccord 2: 0.012709 m; Diamètre nominal max. 12: 0.025 m; Décalage de la largeur: 3.04801 m; Décalage de la hauteur: 3.048 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Cotes - Hauteur de décalage: 12.5000 mm; Largeur de décalage: 12.5085 mm; Rayon nominal 1: 0.0125 m; Diamètre nominal 1: 0.025 m; Diamètre extérieur du raccord 1: 0.0334 m; Taille de la coche 1: 0.01336 m; Rayon nominal 2: 0.0075 m; Diamètre nominal 2: 0.015 m; Diamètre extérieur du raccord 2: 0.025418 m; Taille de la coche 2: 0.0101672 m
Unknown | Ligne d'axe | Unknown | N0 | 1378951 | Raccords de canalisation | Transformation - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø100 mm-ø40 mm | ø100 mm-ø40 mm | 0.102 | Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.0887314 m; Graphismes - Utiliser l'échelle d'annotations: yes; Autre - Rayon extérieur du raccord 1: 0.05715 m; Rayon extérieur du raccord 2: 0.02415 m; Diamètre nominal max. 12: 0.1 m; Décalage de la largeur: 3.048 m; Décalage de la hauteur: 3.04767 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Cotes - Hauteur de décalage: 49.6651 mm; Largeur de décalage: 50.0033 mm; Rayon nominal 1: 0.05 m; Diamètre nominal 1: 0.1 m; Diamètre extérieur du raccord 1: 0.1143 m; Taille de la coche 1: 0.04572 m; Rayon nominal 2: 0.02 m; Diamètre nominal 2: 0.04 m; Diamètre extérieur du raccord 2: 0.0483 m; Taille de la coche 2: 0.01932 m
Unknown | Ligne d'axe | Unknown | N0 | 1379834 | Raccords de canalisation | Coude - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 4 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø40 mm-ø40 mm | ø40 mm-ø40 mm | Autre - Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.0379881 m; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.108502 m; Cotes - Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 90.018 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 | 1379949 | Raccords de canalisation | Transformation - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø100 mm-ø40 mm | ø100 mm-ø40 mm | 0.102 | Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.100979 m; Graphismes - Utiliser l'échelle d'annotations: yes; Autre - Rayon extérieur du raccord 1: 0.05715 m; Rayon extérieur du raccord 2: 0.02415 m; Diamètre nominal max. 12: 0.1 m; Décalage de la largeur: 3.04797 m; Décalage de la hauteur: 3.05567 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Cotes - Hauteur de décalage: 57.6661 mm; Largeur de décalage: 49.9749 mm; Rayon nominal 1: 0.05 m; Diamètre nominal 1: 0.1 m; Diamètre extérieur du raccord 1: 0.1143 m; Taille de la coche 1: 0.04572 m; Rayon nominal 2: 0.02 m; Diamètre nominal 2: 0.04 m; Diamètre extérieur du raccord 2: 0.0483 m; Taille de la coche 2: 0.01932 m
Unknown | Ligne d'axe | Unknown | N0 | 1528545 | Raccords de canalisation | Coude - Générique |  |  | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 4 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø40 mm-ø40 mm | ø40 mm-ø40 mm | Autre - Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.0380009 m; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.108502 m; Cotes - Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 89.9986 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 | 1528707 | Raccords de canalisation | Coude - Générique |  |  | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø40 mm-ø40 mm | ø40 mm-ø40 mm | Autre - Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.038 m; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.108645 m; Cotes - Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 90 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 | 1529474 | Raccords de canalisation | Coude - Générique |  |  | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø40 mm-ø40 mm | ø40 mm-ø40 mm | Autre - Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.0379967 m; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.0883965 m; Cotes - Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 90.005 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 | 1529479 | Raccords de canalisation | Coude - Générique | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées |  |  |  |  |  | 0 | ø40 mm-ø40 mm | ø40 mm-ø40 mm | Autre - Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.0380012 m; Contraintes - Niveau: N0; Élévation par rapport au niveau: 0.521037 m; Cotes - Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 89.9982 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 | 1513071 | Raccords de gaine | Circulaire 90 degrés - Joint coulissant | RIGIDSEGMENT | IfcDuctSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Reprise | Génie climatique Reprise 2 | Reprise |  |  |  |  |  | 0 | ø150 mm-ø80 mm-ø80 mm | ø150-ø80-ø80 | Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.63 m; Graphismes - Utiliser l'échelle d'annotations: yes; Autre - Visibilité 1: yes; Longueur l3: 0.326575 m; Longueur 1: 0.05 m; d12: 0.15 m; Max d1d2d3: 0.15 m; l4: 0.138288 m; d13: 0.08 m; Min d1d2d3: 0.08 m; l3: 0.326575 m; l2 1: 0.05 m; l2 2: 0.05 m; Revêtement - Taille libre: ø150 mm-ø80 mm-ø80 mm; Epaisseur du revêtement: 0 m; Cotes - d1: 0.08 m; r1: 0.04 m; d2: 0.15 m; d3: 0.08 m; r2: 0.075 m; r3: 0.04 m; l2: 0 m; l: 0 m
