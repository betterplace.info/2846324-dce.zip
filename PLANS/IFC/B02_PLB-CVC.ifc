Properties of the parts of a building model (IFC4), part 9 of 10

# IfcBuildingElementPart (358)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
201_PAC GENERIQUE | 201_PAC GENERIQUE | 201_PAC GENERIQUE | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1459242 | Equipement de génie climatique | 2021_015 | Autre - Famille et type: 201_PAC GENERIQUE; Famille: 201_PAC GENERIQUE; Type: 201_PAC GENERIQUE; ID du type: 201_PAC GENERIQUE; Paramètres IFC - Exporter au format IFC: 0; Exporter au format IFC sous: IfcEnergyConversionDevice; Revizto - Architecture: yes; Plumbing: yes; Mechanical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Cotes - Volume: 0.705242 m3; Surface: 4.09494 m2; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Décalage par rapport à l'hôte: 0 m; Hôte: Niveau : N0; Élévation par rapport au niveau: 0 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.3.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1475525; Nom: 201_PAC GENERIQUE; Elévation par défaut: 0 m; Note d'identification: 200_CHAUFFAGE; Catégorie: Equipement de génie climatique; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement de génie climatique : 201_PAC GENERIQUE; Nom de la famille: 201_PAC GENERIQUE; Nom du type: 201_PAC GENERIQUE; Classification: 0; ROP_SUIVIE DE CHANTIER - Installation ?: no
201_PAC GENERIQUE | Instance | 201_PAC GENERIQUE | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1475525 | Equipement de génie climatique | Famille : Equipement de génie climatique : 201_PAC GENERIQUE | Autre - Nom de la famille: 201_PAC GENERIQUE; Données d'identification - Nom du type: 201_PAC GENERIQUE; Note d'identification: 200_CHAUFFAGE; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Classification: 0
Raccords de gaine | Category | Raccords de gaine | N0
Circulaire 90 degrés - Joint coulissant | Family | Circulaire 90 degrés - Joint coulissant | N0
Circulaire 90 degrés - Joint coulissant | Standard | Circulaire 90 degrés - Joint coulissant | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1513070 | Raccords de gaine | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Visibilité 1: yes; Longueur l3: 0.326575 m; Longueur 1: 0.05 m; d12: 0.15 m; Max d1d2d3: 0.15 m; l4: 0.138288 m; d13: 0.08 m; Min d1d2d3: 0.08 m; l3: 0.326575 m; l2 1: 0.05 m; l2 2: 0.05 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Cotes - Volume: 0.00617155 m3; Taille: ø150-ø80-ø80; d1: 0.08 m; r1: 0.04 m; d2: 0.15 m; d3: 0.08 m; r2: 0.075 m; r3: 0.04 m; l2: 0 m; l: 0 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.63 m; Type de Revit - Id: 1037426; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de gaine; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de gaine : Circulaire 90 degrés - Joint coulissant; Nom de la famille: Circulaire 90 degrés - Joint coulissant; Nom du type: Standard; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø150 mm-ø80 mm-ø80 mm; Graphismes - Utiliser l'échelle d'annotations: yes; Revizto - Mechanical: yes; Génie climatique - Débit - Trajectoire critique: no; Revêtement - Taille libre: ø150 mm-ø80 mm-ø80 mm; Epaisseur du revêtement: 0 m
Circulaire 90 degrés - Joint coulissant | Instance | Circulaire 90 degrés - Joint coulissant | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1513115 | Raccords de gaine | Famille : Raccords de gaine : Circulaire 90 degrés - Joint coulissant | Autre - Nom de la famille: Circulaire 90 degrés - Joint coulissant; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0

# IfcBuildingElementProxy (115)
In: B02_PLB.rvt
Elément - Fichier source: B02_PLB.rvt
Informations sur le partage du travail des éléments - État des mises à jour des modèles: CurrentWithCentral; État du retrait: NotOwned; Créateur: boulanger-mathe; Dernière modification par: boulanger-mathe
Paramètres IFC - Exporter au format IFC: 0
Name | Elément, Type | Elément, Nom | Calque | Value = Authoring Tool Id | Autre, Catégorie | Autre, Nom de la famille | Type prédéfini d'IFC | Exporter au format IFC sous | Données d'identification, Sous-projet | Données d'identification, Nom du type | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | Génie climatique, Classification du système | Nom du système | Type de système | GEM_ROP_LIGNE CCTP | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Epaisseur d'isolation (m) | Taille globale | Taille | Longueur (m)
Unknown | Ligne d'axe | Unknown | N0 FINI | 1336596 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 0.56146 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0264582 m2; Contraintes - Arase inférieure à son extrémité aval: 0.591831 m; Arase supérieure à son extrémité amont: 0.613167 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.5946 m; Inclinaison: 0.00%; Elévation du milieu: 0.602499 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1336608 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 1.99814 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0941603 m2; Contraintes - Arase inférieure à son extrémité aval: 0.489331 m; Arase supérieure à son extrémité amont: 0.510668 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.4921 m; Inclinaison: 0.00%; Elévation du milieu: 0.5 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1336643 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 0.121764 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00573801 m2; Contraintes - Arase inférieure à son extrémité aval: 0.578793 m; Arase supérieure à son extrémité amont: 0.600129 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.581562 m; Inclinaison: 0.00%; Elévation du milieu: 0.589461 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1336663 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 0.12 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00565485 m2; Contraintes - Arase inférieure à son extrémité aval: 0.573792 m; Arase supérieure à son extrémité amont: 0.595128 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.576561 m; Inclinaison: 0.00%; Elévation du milieu: 0.58446 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1336679 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 1.10022 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0518467 m2; Contraintes - Arase inférieure à son extrémité aval: 0.489332 m; Arase supérieure à son extrémité amont: 0.510668 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.492101 m; Inclinaison: 0.00%; Elévation du milieu: 0.5 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1336681 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 1.0015 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0471946 m2; Contraintes - Arase inférieure à son extrémité aval: 0.60945 m; Arase supérieure à son extrémité amont: 1.61097 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.609453 m; Inclinaison: 106665.99%; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: 0.60946 m; Elévation de l'axe à son extrémité amont: 1.61096 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1336703 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 1.09082 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0514035 m2; Contraintes - Arase inférieure à son extrémité aval: 0.489331 m; Arase supérieure à son extrémité amont: 0.510667 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.492099 m; Inclinaison: 0.00%; Elévation du milieu: 0.499999 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1336705 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 0.996499 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0469589 m2; Contraintes - Arase inférieure à son extrémité aval: 0.614451 m; Arase supérieure à son extrémité amont: 1.61097 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.614454 m; Inclinaison: 106469.69%; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: 0.614461 m; Elévation de l'axe à son extrémité amont: 1.61096 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1343633 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Hometech | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø100 mm | ø100 mm | 1.79736 | Génie climatique - Type de connexion: Générique; Segment de canalisation: PVC Grey - Hometech; Diamètre: 0.1 m; Rugosité: 0.00002323 m; Matériau: PVC Grey; Nomenclature/type: Hometech; Surface: 0.564658 m2; Description du segment: Hometech; Contraintes - Arase inférieure à son extrémité aval: 0.0213253 m; Arase supérieure à son extrémité amont: 0.139293 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0243251 m; Inclinaison: 1.00%; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: 0.0713228 m; Elévation de l'axe à son extrémité amont: 0.0892955 m; Cotes - Epaisseur de paroi: 0.003 m; Diamètre extérieur: 0.1 m; Diamètre intérieur: 0.094 m; Génie climatique - Débit - Débit par appareil: 0
Unknown | Ligne d'axe | Unknown | N0 FINI | 1344674 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm | ø25 mm | 0.0923221 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00725096 m2; Contraintes - Arase inférieure à son extrémité aval: 1.68326 m; Arase supérieure à son extrémité amont: 1.71666 m; Elévation du fond (fil d'eau) à son extrémité aval: 1.68664 m; Inclinaison: 0.00%; Elévation du milieu: 1.69996 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1344740 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm | ø25 mm | 1.21866 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0957132 m2; Contraintes - Arase inférieure à son extrémité aval: 1.68326 m; Arase supérieure à son extrémité amont: 1.71666 m; Elévation du fond (fil d'eau) à son extrémité aval: 1.68664 m; Inclinaison: 0.00%; Elévation du milieu: 1.69996 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1344826 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 2.12963 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.100356 m2; Contraintes - Arase inférieure à son extrémité aval: 1.68929 m; Arase supérieure à son extrémité amont: 1.71063 m; Elévation du fond (fil d'eau) à son extrémité aval: 1.69206 m; Inclinaison: 0.00%; Elévation du milieu: 1.69996 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1345021 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 0.0435515 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00205232 m2; Contraintes - Arase inférieure à son extrémité aval: 0.515899 m; Arase supérieure à son extrémité amont: 0.55947 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.515901 m; Inclinaison: 106665.99%; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: 0.515909 m; Elévation de l'axe à son extrémité amont: 0.55946 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1345055 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 0.0485538 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00228804 m2; Contraintes - Arase inférieure à son extrémité aval: 0.515897 m; Arase supérieure à son extrémité amont: 0.564471 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.5159 m; Inclinaison: 106469.69%; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: 0.515907 m; Elévation de l'axe à son extrémité amont: 0.564461 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1345076 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 0.0457349 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00215521 m2; Contraintes - Arase inférieure à son extrémité aval: 0.531764 m; Arase supérieure à son extrémité amont: 0.577499 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.531765 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: 0.531765 m; Elévation de l'axe à son extrémité amont: 0.577499 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1345082 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 1.05659 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0497907 m2; Contraintes - Arase inférieure à son extrémité aval: 0.627499 m; Arase supérieure à son extrémité amont: 1.68409 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.627499 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: 0.627499 m; Elévation de l'axe à son extrémité amont: 1.68409 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1348023 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm | ø25 mm | 0.858818 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0674514 m2; Contraintes - Arase inférieure à son extrémité aval: 1.68326 m; Arase supérieure à son extrémité amont: 1.71666 m; Elévation du fond (fil d'eau) à son extrémité aval: 1.68664 m; Inclinaison: 0.00%; Elévation du milieu: 1.69996 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1348141 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm | ø25 mm | 2.4666 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.193726 m2; Contraintes - Arase inférieure à son extrémité aval: 2.6833 m; Arase supérieure à son extrémité amont: 2.7167 m; Elévation du fond (fil d'eau) à son extrémité aval: 2.68668 m; Inclinaison: 0.00%; Elévation du milieu: 2.7 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1348852 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm | ø25 mm | 0.950039 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0746159 m2; Contraintes - Arase inférieure à son extrémité aval: 1.72496 m; Arase supérieure à son extrémité amont: 2.675 m; Elévation du fond (fil d'eau) à son extrémité aval: 1.72496 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: 1.72496 m; Elévation de l'axe à son extrémité amont: 2.675 m; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1349492 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 0.0216619 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00102079 m2; Contraintes - Arase inférieure à son extrémité aval: 0.505245 m; Arase supérieure à son extrémité amont: 0.526581 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.508014 m; Inclinaison: 0.00%; Elévation du milieu: 0.515913 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1349493 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm | ø15 mm | 0.00258542 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.000121835 m2; Contraintes - Arase inférieure à son extrémité aval: 0.498208 m; Arase supérieure à son extrémité amont: 0.517705 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.500561 m; Inclinaison: 61.97%; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: 0.507276 m; Elévation de l'axe à son extrémité amont: 0.508637 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1354919 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 5 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø40 mm | ø40 mm | 0.0254 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00319186 m2; Contraintes - Arase inférieure à son extrémité aval: 0.55187 m; Arase supérieure à son extrémité amont: 0.60013 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.555553 m; Inclinaison: 0.00%; Elévation du milieu: 0.576 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1377790 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm | ø25 mm | 0.041 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00322013 m2; Contraintes - Arase inférieure à son extrémité aval: -0.009 m; Arase supérieure à son extrémité amont: 0.032 m; Elévation du fond (fil d'eau) à son extrémité aval: -0.009 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: -0.009 m; Elévation de l'axe à son extrémité amont: 0.032 m; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1377990 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm | ø25 mm | 0.476566 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0374294 m2; Contraintes - Arase inférieure à son extrémité aval: 2.6833 m; Arase supérieure à son extrémité amont: 2.71674 m; Elévation du fond (fil d'eau) à son extrémité aval: 2.68668 m; Inclinaison: 0.01%; Elévation du milieu: 2.70004 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1378029 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm | ø25 mm | 0.150435 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0118151 m2; Contraintes - Arase inférieure à son extrémité aval: 2.68328 m; Arase supérieure à son extrémité amont: 2.7167 m; Elévation du fond (fil d'eau) à son extrémité aval: 2.68666 m; Inclinaison: 0.00%; Elévation du milieu: 2.7 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1378194 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm | ø25 mm | 2.56705 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.201615 m2; Contraintes - Arase inférieure à son extrémité aval: 0.108 m; Arase supérieure à son extrémité amont: 2.67505 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.108 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: 0.108 m; Elévation de l'axe à son extrémité amont: 2.67505 m; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Génie climatique - Débit - Débit par appareil: 0; Débit supplémentaire: 0.0 L/s
Unknown | Ligne d'axe | Unknown | N0 FINI | 1378944 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Hometech | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø100 mm | ø100 mm | 0.868876 | Génie climatique - Type de connexion: Générique; Segment de canalisation: PVC Grey - Hometech; Diamètre: 0.1 m; Rugosité: 0.00002323 m; Matériau: PVC Grey; Nomenclature/type: Hometech; Surface: 0.272965 m2; Description du segment: Hometech; Contraintes - Arase inférieure à son extrémité aval: -0.00100442 m; Arase supérieure à son extrémité amont: 0.107679 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.00199543 m; Inclinaison: 1.00%; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: 0.0489931 m; Elévation de l'axe à son extrémité amont: 0.0576814 m; Cotes - Epaisseur de paroi: 0.003 m; Diamètre extérieur: 0.1 m; Diamètre intérieur: 0.094 m; Génie climatique - Débit - Débit par appareil: 0
Unknown | Ligne d'axe | Unknown | N0 FINI | 1379107 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø40 mm | ø40 mm | 0.358768 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0450841 m2; Contraintes - Arase inférieure à son extrémité aval: 0.0938264 m; Arase supérieure à son extrémité amont: 0.455607 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0941903 m; Inclinaison: 1007.15%; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: 0.0962105 m; Elévation de l'axe à son extrémité amont: 0.453223 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Génie climatique - Débit - Débit par appareil: 0
Unknown | Ligne d'axe | Unknown | N0 FINI | 1379942 | Canalisation | Canalisation | RIGIDSEGMENT | IfcPipeSegmentType | 2021_015 | Hometech | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø100 mm | ø100 mm | 1.08539 | Génie climatique - Type de connexion: Générique; Segment de canalisation: PVC Grey - Hometech; Diamètre: 0.1 m; Rugosité: 0.00002323 m; Matériau: PVC Grey; Nomenclature/type: Hometech; Surface: 0.340985 m2; Description du segment: Hometech; Contraintes - Arase inférieure à son extrémité aval: 0.0097838 m; Arase supérieure à son extrémité amont: 0.120632 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0127837 m; Inclinaison: 1.00%; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Elévation de l'axe à son extrémité aval: 0.0597813 m; Elévation de l'axe à son extrémité amont: 0.0706347 m; Cotes - Epaisseur de paroi: 0.003 m; Diamètre extérieur: 0.1 m; Diamètre intérieur: 0.094 m; Génie climatique - Débit - Débit par appareil: 0
Unknown | Ligne d'axe | Unknown | N0 FINI | 1528538 | Canalisation | Canalisation |  |  | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 4 | Eaux Usées |  |  |  |  |  | 0 | ø40 mm | ø40 mm | 0.0195067 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00245128 m2; Contraintes - Arase inférieure à son extrémité aval: 0.466907 m; Arase supérieure à son extrémité amont: 0.515167 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.47059 m; Inclinaison: 0.00%; Elévation du milieu: 0.491037 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Génie climatique - Débit - Débit par appareil: 0
Unknown | Ligne d'axe | Unknown | N0 FINI | 1528700 | Canalisation | Canalisation |  |  | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Sanitaire | Eaux Usées 3 | Eaux Usées |  |  |  |  |  | 0 | ø40 mm | ø40 mm | 0.0195067 | Génie climatique - Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00245128 m2; Contraintes - Arase inférieure à son extrémité aval: 0.466907 m; Arase supérieure à son extrémité amont: 0.515167 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.47059 m; Inclinaison: 0.00%; Elévation du milieu: 0.491037 m; Justification verticale: 0; Justification horizontale: 0; Niveau de référence: N0 FINI; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Génie climatique - Débit - Débit par appareil: 0
Unknown | Ligne d'axe | Unknown | N0 FINI | 1344685 | Raccords de canalisation | Té - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm-ø25 mm-ø25 mm | ø25 mm-ø25 mm-ø25 mm | Autre - Rayon extérieur du raccord: 0.0167 m; Libellé de centre à extrémité: 0.038 m; Angle 1: 89.9463 deg; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 1.69996 m; Cotes - Rayon nominal: 0.0125 m; Diamètre nominal: 0.025 m; Diamètre extérieur du raccord: 0.0334 m; Taille de la coche: 0.01336 m; Centre à extrémité: 0.038 m; Angle: 90.0537 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1344741 | Raccords de canalisation | Té - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm-ø25 mm-ø25 mm | ø25 mm-ø25 mm-ø25 mm | Autre - Rayon extérieur du raccord: 0.0167 m; Libellé de centre à extrémité: 0.038 m; Angle 1: 89.9462 deg; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 1.69996 m; Cotes - Rayon nominal: 0.0125 m; Diamètre nominal: 0.025 m; Diamètre extérieur du raccord: 0.0334 m; Taille de la coche: 0.01336 m; Centre à extrémité: 0.038 m; Angle: 89.9462 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1344883 | Raccords de canalisation | Coude - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø15 mm | ø15 mm-ø15 mm | Autre - Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.015909 m; Rayon du centre: 0.015909 m; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 1.7 m; Cotes - Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 90 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1345022 | Raccords de canalisation | Té - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø15 mm-ø15 mm | ø15 mm-ø15 mm-ø15 mm | Autre - Rayon extérieur du raccord: 0.01065 m; Libellé de centre à extrémité: 0.025 m; Angle 1: 89.9463 deg; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.58446 m; Cotes - Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.0213 m; Taille de la coche: 0.00852 m; Centre à extrémité: 0.025 m; Angle: 90.0537 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1345056 | Raccords de canalisation | Té - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø15 mm-ø15 mm | ø15 mm-ø15 mm-ø15 mm | Autre - Rayon extérieur du raccord: 0.01065 m; Libellé de centre à extrémité: 0.025 m; Angle 1: 89.9462 deg; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.589461 m; Cotes - Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.0213 m; Taille de la coche: 0.00852 m; Centre à extrémité: 0.025 m; Angle: 90.0538 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1345083 | Raccords de canalisation | Té - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø15 mm-ø15 mm | ø15 mm-ø15 mm-ø15 mm | Autre - Rayon extérieur du raccord: 0.01065 m; Libellé de centre à extrémité: 0.025 m; Angle 1: 90 deg; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.602499 m; Cotes - Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.0213 m; Taille de la coche: 0.00852 m; Centre à extrémité: 0.025 m; Angle: 90 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1345972 | Raccords de canalisation | Transformation - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø10 mm | ø15 mm-ø10 mm | 0.0794453 | Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.720555 m; Graphismes - Utiliser l'échelle d'annotations: yes; Autre - Rayon extérieur du raccord 1: 0.010209 m; Rayon extérieur du raccord 2: 0.012709 m; Diamètre nominal max. 12: 0.015 m; Décalage de la largeur: 3.048 m; Décalage de la hauteur: 3.048 m; Visibilité 1: no; Visibilité 2: no; Visibilité 3: yes; Cotes - Hauteur de décalage: 5.0000 mm; Largeur de décalage: 5.0000 mm; Rayon nominal 1: 0.005 m; Diamètre nominal 1: 0.01 m; Diamètre extérieur du raccord 1: 0.020418 m; Taille de la coche 1: 0.00816719 m; Rayon nominal 2: 0.0075 m; Diamètre nominal 2: 0.015 m; Diamètre extérieur du raccord 2: 0.025418 m; Taille de la coche 2: 0.0101672 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1346066 | Raccords de canalisation | Transformation - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø10 mm | ø15 mm-ø10 mm | 0.0794453 | Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.8 m; Graphismes - Utiliser l'échelle d'annotations: yes; Autre - Rayon extérieur du raccord 1: 0.012709 m; Rayon extérieur du raccord 2: 0.010209 m; Diamètre nominal max. 12: 0.015 m; Décalage de la largeur: 3.048 m; Décalage de la hauteur: 3.048 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Cotes - Hauteur de décalage: 7.5000 mm; Largeur de décalage: 7.5000 mm; Rayon nominal 1: 0.0075 m; Diamètre nominal 1: 0.015 m; Diamètre extérieur du raccord 1: 0.025418 m; Taille de la coche 1: 0.0101672 m; Rayon nominal 2: 0.005 m; Diamètre nominal 2: 0.01 m; Diamètre extérieur du raccord 2: 0.020418 m; Taille de la coche 2: 0.00816719 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1346207 | Raccords de canalisation | Transformation - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø10 mm | ø15 mm-ø10 mm | 0.0794453 | Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.8 m; Graphismes - Utiliser l'échelle d'annotations: yes; Autre - Rayon extérieur du raccord 1: 0.012709 m; Rayon extérieur du raccord 2: 0.010209 m; Diamètre nominal max. 12: 0.015 m; Décalage de la largeur: 3.048 m; Décalage de la hauteur: 3.048 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Cotes - Hauteur de décalage: 7.5000 mm; Largeur de décalage: 7.5000 mm; Rayon nominal 1: 0.0075 m; Diamètre nominal 1: 0.015 m; Diamètre extérieur du raccord 1: 0.025418 m; Taille de la coche 1: 0.0101672 m; Rayon nominal 2: 0.005 m; Diamètre nominal 2: 0.01 m; Diamètre extérieur du raccord 2: 0.020418 m; Taille de la coche 2: 0.00816719 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1346294 | Raccords de canalisation | Transformation - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm-ø15 mm | ø25 mm-ø15 mm | 0.051 | Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 1.66196 m; Graphismes - Utiliser l'échelle d'annotations: yes; Autre - Rayon extérieur du raccord 1: 0.0167 m; Rayon extérieur du raccord 2: 0.012709 m; Diamètre nominal max. 12: 0.025 m; Décalage de la largeur: 3.048 m; Décalage de la hauteur: 3.048 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Cotes - Hauteur de décalage: 12.5000 mm; Largeur de décalage: 12.5000 mm; Rayon nominal 1: 0.0125 m; Diamètre nominal 1: 0.025 m; Diamètre extérieur du raccord 1: 0.0334 m; Taille de la coche 1: 0.01336 m; Rayon nominal 2: 0.0075 m; Diamètre nominal 2: 0.015 m; Diamètre extérieur du raccord 2: 0.025418 m; Taille de la coche 2: 0.0101672 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1346296 | Raccords de canalisation | Transformation - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm-ø15 mm | ø25 mm-ø15 mm | 0.051 | Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 1.69996 m; Graphismes - Utiliser l'échelle d'annotations: yes; Autre - Rayon extérieur du raccord 1: 0.0167 m; Rayon extérieur du raccord 2: 0.012709 m; Diamètre nominal max. 12: 0.025 m; Décalage de la largeur: 3.048 m; Décalage de la hauteur: 3.048 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Cotes - Hauteur de décalage: 12.5000 mm; Largeur de décalage: 12.5000 mm; Rayon nominal 1: 0.0125 m; Diamètre nominal 1: 0.025 m; Diamètre extérieur du raccord 1: 0.0334 m; Taille de la coche 1: 0.01336 m; Rayon nominal 2: 0.0075 m; Diamètre nominal 2: 0.015 m; Diamètre extérieur du raccord 2: 0.025418 m; Taille de la coche 2: 0.0101672 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1346298 | Raccords de canalisation | Transformation - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm-ø15 mm | ø25 mm-ø15 mm | 0.051 | Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 1.66196 m; Graphismes - Utiliser l'échelle d'annotations: yes; Autre - Rayon extérieur du raccord 1: 0.0167 m; Rayon extérieur du raccord 2: 0.012709 m; Diamètre nominal max. 12: 0.025 m; Décalage de la largeur: 3.048 m; Décalage de la hauteur: 3.048 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Cotes - Hauteur de décalage: 12.5000 mm; Largeur de décalage: 12.5000 mm; Rayon nominal 1: 0.0125 m; Diamètre nominal 1: 0.025 m; Diamètre extérieur du raccord 1: 0.0334 m; Taille de la coche 1: 0.01336 m; Rayon nominal 2: 0.0075 m; Diamètre nominal 2: 0.015 m; Diamètre extérieur du raccord 2: 0.025418 m; Taille de la coche 2: 0.0101672 m
Unknown | Ligne d'axe | Unknown | N0 FINI | 1348854 | Raccords de canalisation | Coude - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm-ø25 mm | ø25 mm-ø25 mm | Autre - Rayon extérieur du raccord: 0.0167 m; Libellé de centre à extrémité: 0.025 m; Rayon du centre: 0.025 m; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 1.69996 m; Cotes - Rayon nominal: 0.0125 m; Diamètre nominal: 0.025 m; Diamètre extérieur du raccord: 0.0334 m; Taille de la coche: 0.01336 m; Centre à extrémité: 0.025 m; Angle: 90 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1349026 | Raccords de canalisation | Coude - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø15 mm | ø15 mm-ø15 mm | Autre - Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.015909 m; Rayon du centre: 0.015909 m; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.499999 m; Cotes - Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 90 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1349128 | Raccords de canalisation | Coude - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø15 mm | ø15 mm-ø15 mm | Autre - Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.015909 m; Rayon du centre: 0.015909 m; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.5 m; Cotes - Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 90 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1349495 | Raccords de canalisation | Coude - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø15 mm | ø15 mm-ø15 mm | Autre - Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.0158516 m; Rayon du centre: 0.015909 m; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.515913 m; Cotes - Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 89.793 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1349497 | Raccords de canalisation | Coude - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø15 mm | ø15 mm-ø15 mm | Autre - Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.0138117 m; Rayon du centre: 0.048507 m; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.515913 m; Cotes - Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 31.7872 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1349567 | Raccords de canalisation | Coude - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø15 mm | ø15 mm-ø15 mm | Autre - Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.0138117 m; Rayon du centre: 0.048507 m; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.5 m; Cotes - Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 31.7872 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1351744 | Raccords de canalisation | RACCORD REDUCTEUR 15-10 | TRANSITION | IfcPipeFittingType | 2021_015 | RACCORD REDUCTEUR 15-10 | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø10 mm | ø15 mm-ø10 mm | Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.5 m; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1352689 | Raccords de canalisation | RACCORD REDUCTEUR 15-10 | TRANSITION | IfcPipeFittingType | 2021_015 | RACCORD REDUCTEUR 15-10 | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø10 mm | ø15 mm-ø10 mm | Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.499999 m; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1352752 | Raccords de canalisation | RACCORD REDUCTEUR 15-10 | TRANSITION | IfcPipeFittingType | 2021_015 | RACCORD REDUCTEUR 15-10 | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø15 mm-ø10 mm | ø15 mm-ø10 mm | Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.499999 m; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1354921 | Raccords de canalisation | Coude - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 5 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø40 mm-ø40 mm | ø40 mm-ø40 mm | Autre - Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.0379095 m; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.576 m; Cotes - Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 90.1366 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1377810 | Raccords de canalisation | Coude - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm-ø25 mm | ø25 mm-ø25 mm | Autre - Rayon extérieur du raccord: 0.0167 m; Libellé de centre à extrémité: 0.025 m; Rayon du centre: 0.0249979 m; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 2.70005 m; Cotes - Rayon nominal: 0.0125 m; Diamètre nominal: 0.025 m; Diamètre extérieur du raccord: 0.0334 m; Taille de la coche: 0.01336 m; Centre à extrémité: 0.025 m; Angle: 90.0049 deg; Graphismes - Utiliser l'échelle d'annotations: yes
Unknown | Ligne d'axe | Unknown | N0 FINI | 1377985 | Raccords de canalisation | Coude - Générique | JUNCTION | IfcPipeFittingType | 2021_015 | Standard | Phases | 1 | Existant | Paramètres des phases | 12589 | Eau froide sanitaire | Eau Froide Sanitaire 1 | Eau Froide Sanitaire | 2.2 | 2021_015 | 03 | KC | PLOMBERIE/CVC | 0 | ø25 mm-ø25 mm | ø25 mm-ø25 mm | Autre - Rayon extérieur du raccord: 0.0167 m; Libellé de centre à extrémité: 0.025 m; Rayon du centre: 0.025 m; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 2.7 m; Cotes - Rayon nominal: 0.0125 m; Diamètre nominal: 0.025 m; Diamètre extérieur du raccord: 0.0334 m; Taille de la coche: 0.01336 m; Centre à extrémité: 0.025 m; Angle: 90 deg; Graphismes - Utiliser l'échelle d'annotations: yes
