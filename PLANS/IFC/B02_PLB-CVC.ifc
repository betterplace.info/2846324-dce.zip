Properties of the parts of a building model (IFC4), part 3 of 10

# IfcBuildingElementPart (358)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1378193 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.118 m; Diamètre: 0.025 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.201615 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00171592; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 83; Contraintes - Arase inférieure à son extrémité aval: 0.108 m; Arase supérieure à son extrémité amont: 2.67505 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.108 m; Elévation du fond (fil d'eau) à son extrémité amont: 2.67505 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.108 m; Elévation du point haut intérieur du tube à son extrémité amont: 2.67505 m; Arase supérieure à son extrémité aval: 0.108 m; Arase inférieure à son extrémité amont: 2.67505 m; Elévation de l'axe à son extrémité aval: 0.108 m; Elévation de l'axe à son extrémité amont: 2.67505 m; Elévation du milieu: 2.67505 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.108 m; Élévation centrale de départ: 2.67505 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm; Arase inférieure avec isolant à son extrémité aval: 0.108 m; Arase supérieure avec isolant à son extrémité aval: 0.108 m; Arase inférieure avec isolant à son extrémité amont: 2.67505 m; Arase supérieure avec isolant à son extrémité amont: 2.67505 m; Cotes - Epaisseur de paroi: 0.0033782 m; Diamètre extérieur: 0.033401 m; Diamètre intérieur: 0.0266446 m; Taille: ø25 mm; Longueur: 2.56705 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1379106 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.10419 m; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0450841 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit par appareil: 0; Rugosité relative: 0.00111801; Tronçon: 13; Contraintes - Arase inférieure à son extrémité aval: 0.0938264 m; Arase supérieure à son extrémité amont: 0.455607 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0941903 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.451203 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.0982308 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.455243 m; Arase supérieure à son extrémité aval: 0.0985947 m; Arase inférieure à son extrémité amont: 0.450839 m; Elévation de l'axe à son extrémité aval: 0.0962105 m; Elévation de l'axe à son extrémité amont: 0.453223 m; Inclinaison: 1007.15%; Elévation du milieu: 0.0962105 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.453223 m; Élévation centrale de départ: 0.0962105 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm; Arase inférieure avec isolant à son extrémité aval: 0.0938264 m; Arase supérieure avec isolant à son extrémité aval: 0.0985947 m; Arase inférieure avec isolant à son extrémité amont: 0.450839 m; Arase supérieure avec isolant à son extrémité amont: 0.455607 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Taille: ø40 mm; Longueur: 0.358768 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1528537 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 4; Type de système: Eaux Usées; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.48059 m; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00245128 m2; Phase de construction - Phase de création: Existant; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit par appareil: 0; Rugosité relative: 0.00111801; Tronçon: 1; Contraintes - Arase inférieure à son extrémité aval: 0.466907 m; Arase supérieure à son extrémité amont: 0.515167 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.47059 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.47059 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.511484 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.511484 m; Arase supérieure à son extrémité aval: 0.515167 m; Arase inférieure à son extrémité amont: 0.466907 m; Elévation de l'axe à son extrémité aval: 0.491037 m; Elévation de l'axe à son extrémité amont: 0.491037 m; Inclinaison: 0.00%; Elévation du milieu: 0.491037 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.491037 m; Élévation centrale de départ: 0.491037 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm; Arase inférieure avec isolant à son extrémité aval: 0.466907 m; Arase supérieure avec isolant à son extrémité aval: 0.515167 m; Arase inférieure avec isolant à son extrémité amont: 0.466907 m; Arase supérieure avec isolant à son extrémité amont: 0.515167 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Taille: ø40 mm; Longueur: 0.0195067 m
Canalisation | Standard | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1528699 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.48059 m; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00245128 m2; Phase de construction - Phase de création: Existant; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit par appareil: 0; Rugosité relative: 0.00111801; Tronçon: 2; Contraintes - Arase inférieure à son extrémité aval: 0.466907 m; Arase supérieure à son extrémité amont: 0.515167 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.47059 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.47059 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.511484 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.511484 m; Arase supérieure à son extrémité aval: 0.515167 m; Arase inférieure à son extrémité amont: 0.466907 m; Elévation de l'axe à son extrémité aval: 0.491037 m; Elévation de l'axe à son extrémité amont: 0.491037 m; Inclinaison: 0.00%; Elévation du milieu: 0.491037 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.491037 m; Élévation centrale de départ: 0.491037 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm; Arase inférieure avec isolant à son extrémité aval: 0.466907 m; Arase supérieure avec isolant à son extrémité aval: 0.515167 m; Arase inférieure avec isolant à son extrémité amont: 0.466907 m; Arase supérieure avec isolant à son extrémité amont: 0.515167 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Taille: ø40 mm; Longueur: 0.0195067 m
Hometech | Type | Hometech | N0 FINI
Canalisation | Hometech | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1343632 | Canalisation | 2021_015 | Autre - Famille et type: Hometech; Famille: Hometech; Type: Hometech; ID du type: Hometech; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Type de connexion: Générique; Segment de canalisation: PVC Grey - Hometech; Elévation du fond (fil d'eau): 0.0343251 m; Diamètre: 0.1 m; Rugosité: 0.00002323 m; Matériau: PVC Grey; Nomenclature/type: Hometech; Surface: 0.564658 m2; Description du segment: Hometech; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1083932; Nom: Hometech; Catégorie: Canalisation; Exporter le type au format IFC: 0; Modèle: Hometech; Fabricant: Aliaxis FR; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Hometech; Génie climatique - Débit - Débit par appareil: 0; Rugosité relative: 0.000247128; Tronçon: 16; Contraintes - Arase inférieure à son extrémité aval: 0.0213253 m; Arase supérieure à son extrémité amont: 0.139293 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0243251 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.0422978 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.11832 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.136293 m; Arase supérieure à son extrémité aval: 0.12132 m; Arase inférieure à son extrémité amont: 0.039298 m; Elévation de l'axe à son extrémité aval: 0.0713228 m; Elévation de l'axe à son extrémité amont: 0.0892955 m; Inclinaison: 1.00%; Elévation du milieu: 0.0713228 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.0892955 m; Élévation centrale de départ: 0.0713228 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø100 mm; Arase inférieure avec isolant à son extrémité aval: 0.0213253 m; Arase supérieure avec isolant à son extrémité aval: 0.12132 m; Arase inférieure avec isolant à son extrémité amont: 0.039298 m; Arase supérieure avec isolant à son extrémité amont: 0.139293 m; Cotes - Epaisseur de paroi: 0.003 m; Diamètre extérieur: 0.1 m; Diamètre intérieur: 0.094 m; Taille: ø100 mm; Longueur: 1.79736 m
Canalisation | Hometech | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1378943 | Canalisation | 2021_015 | Autre - Famille et type: Hometech; Famille: Hometech; Type: Hometech; ID du type: Hometech; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Type de connexion: Générique; Segment de canalisation: PVC Grey - Hometech; Elévation du fond (fil d'eau): 0.0119954 m; Diamètre: 0.1 m; Rugosité: 0.00002323 m; Matériau: PVC Grey; Nomenclature/type: Hometech; Surface: 0.272965 m2; Description du segment: Hometech; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1083932; Nom: Hometech; Catégorie: Canalisation; Exporter le type au format IFC: 0; Modèle: Hometech; Fabricant: Aliaxis FR; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Hometech; Génie climatique - Débit - Débit par appareil: 0; Rugosité relative: 0.000247128; Tronçon: 14; Contraintes - Arase inférieure à son extrémité aval: -0.00100442 m; Arase supérieure à son extrémité amont: 0.107679 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.00199543 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.0106838 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.0959907 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.104679 m; Arase supérieure à son extrémité aval: 0.0989906 m; Arase inférieure à son extrémité amont: 0.00768391 m; Elévation de l'axe à son extrémité aval: 0.0489931 m; Elévation de l'axe à son extrémité amont: 0.0576814 m; Inclinaison: 1.00%; Elévation du milieu: 0.0489931 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.0576814 m; Élévation centrale de départ: 0.0489931 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø100 mm; Arase inférieure avec isolant à son extrémité aval: -0.00100442 m; Arase supérieure avec isolant à son extrémité aval: 0.0989906 m; Arase inférieure avec isolant à son extrémité amont: 0.00768391 m; Arase supérieure avec isolant à son extrémité amont: 0.107679 m; Cotes - Epaisseur de paroi: 0.003 m; Diamètre extérieur: 0.1 m; Diamètre intérieur: 0.094 m; Taille: ø100 mm; Longueur: 0.868876 m
Canalisation | Hometech | Canalisation | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1379941 | Canalisation | 2021_015 | Autre - Famille et type: Hometech; Famille: Hometech; Type: Hometech; ID du type: Hometech; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Type de connexion: Générique; Segment de canalisation: PVC Grey - Hometech; Elévation du fond (fil d'eau): 0.0227837 m; Diamètre: 0.1 m; Rugosité: 0.00002323 m; Matériau: PVC Grey; Nomenclature/type: Hometech; Surface: 0.340985 m2; Description du segment: Hometech; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1083932; Nom: Hometech; Catégorie: Canalisation; Exporter le type au format IFC: 0; Modèle: Hometech; Fabricant: Aliaxis FR; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Hometech; Génie climatique - Débit - Débit par appareil: 0; Rugosité relative: 0.000247128; Tronçon: 6; Contraintes - Arase inférieure à son extrémité aval: 0.0097838 m; Arase supérieure à son extrémité amont: 0.120632 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0127837 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.023637 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.106779 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.117632 m; Arase supérieure à son extrémité aval: 0.109779 m; Arase inférieure à son extrémité amont: 0.0206371 m; Elévation de l'axe à son extrémité aval: 0.0597813 m; Elévation de l'axe à son extrémité amont: 0.0706347 m; Inclinaison: 1.00%; Elévation du milieu: 0.0597813 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.0706347 m; Élévation centrale de départ: 0.0597813 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø100 mm; Arase inférieure avec isolant à son extrémité aval: 0.0097838 m; Arase supérieure avec isolant à son extrémité aval: 0.109779 m; Arase inférieure avec isolant à son extrémité amont: 0.0206371 m; Arase supérieure avec isolant à son extrémité amont: 0.120632 m; Cotes - Epaisseur de paroi: 0.003 m; Diamètre extérieur: 0.1 m; Diamètre intérieur: 0.094 m; Taille: ø100 mm; Longueur: 1.08539 m
3 x Ligne d'axe | Category | Ligne d'axe | N0 FINI
Raccords de canalisation | Category | Raccords de canalisation | N0 FINI
Té - Générique | Family | Té - Générique | N0 FINI
Té - Générique | Standard | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1344682 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.0167 m; Libellé de centre à extrémité: 0.038 m; Angle 1: 89.9463 deg; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000874588 m3; Taille: ø25 mm-ø25 mm-ø25 mm; Taille maximale: 0.025 m; Taille minimale: 0.025 m; Rayon nominal: 0.0125 m; Diamètre nominal: 0.025 m; Diamètre extérieur du raccord: 0.0334 m; Taille de la coche: 0.01336 m; Centre à extrémité: 0.038 m; Angle: 90.0537 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 1.69996 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642936; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Té - Générique; Nom de la famille: Té - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Tee; Nom de la table de consultation: Tee - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm-ø25 mm-ø25 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Té - Générique | Instance | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1346291 | Raccords de canalisation | Famille : Raccords de canalisation : Té - Générique | Autre - Nom de la famille: Té - Générique; Nom de la table de consultation: Tee - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Tee
Té - Générique | Standard | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1344738 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.0167 m; Libellé de centre à extrémité: 0.038 m; Angle 1: 89.9462 deg; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000874588 m3; Taille: ø25 mm-ø25 mm-ø25 mm; Taille maximale: 0.025 m; Taille minimale: 0.025 m; Rayon nominal: 0.0125 m; Diamètre nominal: 0.025 m; Diamètre extérieur du raccord: 0.0334 m; Taille de la coche: 0.01336 m; Centre à extrémité: 0.038 m; Angle: 89.9462 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 1.69996 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642936; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Té - Générique; Nom de la famille: Té - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Tee; Nom de la table de consultation: Tee - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm-ø25 mm-ø25 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Té - Générique | Instance | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1346292 | Raccords de canalisation | Famille : Raccords de canalisation : Té - Générique | Autre - Nom de la famille: Té - Générique; Nom de la table de consultation: Tee - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Tee
Té - Générique | Standard | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345019 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.01065 m; Libellé de centre à extrémité: 0.025 m; Angle 1: 89.9463 deg; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000235024 m3; Taille: ø15 mm-ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.0213 m; Taille de la coche: 0.00852 m; Centre à extrémité: 0.025 m; Angle: 90.0537 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.58446 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642936; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Té - Générique; Nom de la famille: Té - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Tee; Nom de la table de consultation: Tee - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Té - Générique | Instance | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1344686 | Raccords de canalisation | Famille : Raccords de canalisation : Té - Générique | Autre - Nom de la famille: Té - Générique; Nom de la table de consultation: Tee - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Tee
Té - Générique | Standard | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345053 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.01065 m; Libellé de centre à extrémité: 0.025 m; Angle 1: 89.9462 deg; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000235024 m3; Taille: ø15 mm-ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.0213 m; Taille de la coche: 0.00852 m; Centre à extrémité: 0.025 m; Angle: 90.0538 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.589461 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642936; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Té - Générique; Nom de la famille: Té - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Tee; Nom de la table de consultation: Tee - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Té - Générique | Instance | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345048 | Raccords de canalisation | Famille : Raccords de canalisation : Té - Générique | Autre - Nom de la famille: Té - Générique; Nom de la table de consultation: Tee - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Tee
Té - Générique | Standard | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345080 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.01065 m; Libellé de centre à extrémité: 0.025 m; Angle 1: 90 deg; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000235024 m3; Taille: ø15 mm-ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.0213 m; Taille de la coche: 0.00852 m; Centre à extrémité: 0.025 m; Angle: 90 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.602499 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642936; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Té - Générique; Nom de la famille: Té - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Tee; Nom de la table de consultation: Tee - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Té - Générique | Instance | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 642936 | Raccords de canalisation | Famille : Raccords de canalisation : Té - Générique | Autre - Nom de la famille: Té - Générique; Nom de la table de consultation: Tee - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Tee
Té - Générique | Standard | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1377988 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.0167 m; Libellé de centre à extrémité: 0.038 m; Angle 1: 89.9889 deg; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000874588 m3; Taille: ø25 mm-ø25 mm-ø25 mm; Taille maximale: 0.025 m; Taille minimale: 0.025 m; Rayon nominal: 0.0125 m; Diamètre nominal: 0.025 m; Diamètre extérieur du raccord: 0.0334 m; Taille de la coche: 0.01336 m; Centre à extrémité: 0.038 m; Angle: 89.9889 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 2.7 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642936; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Té - Générique; Nom de la famille: Té - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Tee; Nom de la table de consultation: Tee - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm-ø25 mm-ø25 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Té - Générique | Instance | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1377992 | Raccords de canalisation | Famille : Raccords de canalisation : Té - Générique | Autre - Nom de la famille: Té - Générique; Nom de la table de consultation: Tee - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Tee
Té - Générique | Standard | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1378942 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.05715 m; Libellé de centre à extrémité: 0.105 m; Angle 1: 89.9996 deg; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Cotes - Volume: 0.00273425 m3; Taille: ø100 mm-ø100 mm-ø100 mm; Taille maximale: 0.1 m; Taille minimale: 0.1 m; Rayon nominal: 0.05 m; Diamètre nominal: 0.1 m; Diamètre extérieur du raccord: 0.1143 m; Taille de la coche: 0.04572 m; Centre à extrémité: 0.105 m; Angle: 89.9996 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.0587314 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642936; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Té - Générique; Nom de la famille: Té - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Tee; Nom de la table de consultation: Tee - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø100 mm-ø100 mm-ø100 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Té - Générique | Instance | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1378801 | Raccords de canalisation | Famille : Raccords de canalisation : Té - Générique | Autre - Nom de la famille: Té - Générique; Nom de la table de consultation: Tee - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Tee
Té - Générique | Standard | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1379940 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.05715 m; Libellé de centre à extrémité: 0.105 m; Angle 1: 90 deg; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Cotes - Volume: 0.00273425 m3; Taille: ø100 mm-ø100 mm-ø100 mm; Taille maximale: 0.1 m; Taille minimale: 0.1 m; Rayon nominal: 0.05 m; Diamètre nominal: 0.1 m; Diamètre extérieur du raccord: 0.1143 m; Taille de la coche: 0.04572 m; Centre à extrémité: 0.105 m; Angle: 90 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.0709787 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642936; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Té - Générique; Nom de la famille: Té - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Tee; Nom de la table de consultation: Tee - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø100 mm-ø100 mm-ø100 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Té - Générique | Instance | Té - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1379150 | Raccords de canalisation | Famille : Raccords de canalisation : Té - Générique | Autre - Nom de la famille: Té - Générique; Nom de la table de consultation: Tee - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Tee
Coude - Générique | Family | Coude - Générique | N0 FINI
Coude - Générique | Standard | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1344882 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.015909 m; Rayon du centre: 0.015909 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.00001268 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 90 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 1.7 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Coude - Générique | Instance | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 733349 | Raccords de canalisation | Famille : Raccords de canalisation : Coude - Générique | Autre - Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Coude - Générique | Standard | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1348853 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.0167 m; Libellé de centre à extrémité: 0.025 m; Rayon du centre: 0.025 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000344056 m3; Taille: ø25 mm-ø25 mm; Taille maximale: 0.025 m; Taille minimale: 0.025 m; Rayon nominal: 0.0125 m; Diamètre nominal: 0.025 m; Diamètre extérieur du raccord: 0.0334 m; Taille de la coche: 0.01336 m; Centre à extrémité: 0.025 m; Angle: 90 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 1.69996 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm-ø25 mm; Graphismes - Utiliser l'échelle d'annotations: yes
2 x Coude - Générique | Instance | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 642146 | Raccords de canalisation | Famille : Raccords de canalisation : Coude - Générique | Autre - Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Coude - Générique | Standard | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1349025 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.015909 m; Rayon du centre: 0.015909 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.00001268 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 90 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.499999 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Coude - Générique | Instance | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1349027 | Raccords de canalisation | Famille : Raccords de canalisation : Coude - Générique | Autre - Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Coude - Générique | Standard | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1349127 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.015909 m; Rayon du centre: 0.015909 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.00001268 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 90 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.5 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Coude - Générique | Instance | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1349129 | Raccords de canalisation | Famille : Raccords de canalisation : Coude - Générique | Autre - Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Coude - Générique | Standard | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1349494 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.0158516 m; Rayon du centre: 0.015909 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000126509 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 89.793 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.515913 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Coude - Générique | Instance | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1349482 | Raccords de canalisation | Famille : Raccords de canalisation : Coude - Générique | Autre - Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Coude - Générique | Standard | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1349496 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.0138117 m; Rayon du centre: 0.048507 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000136548 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 31.7872 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.515913 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
2 x Coude - Générique | Instance | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1349498 | Raccords de canalisation | Famille : Raccords de canalisation : Coude - Générique | Autre - Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Coude - Générique | Standard | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1349566 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.012709 m; Libellé de centre à extrémité: 0.0138117 m; Rayon du centre: 0.048507 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000136548 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; Rayon nominal: 0.0075 m; Diamètre nominal: 0.015 m; Diamètre extérieur du raccord: 0.025418 m; Taille de la coche: 0.0101672 m; Centre à extrémité: 0.0138117 m; Angle: 31.7872 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.5 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Coude - Générique | Standard | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1354920 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.0379095 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 5; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.000109269 m3; Taille: ø40 mm-ø40 mm; Taille maximale: 0.04 m; Taille minimale: 0.04 m; Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 90.1366 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.576 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm-ø40 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Coude - Générique | Instance | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1354922 | Raccords de canalisation | Famille : Raccords de canalisation : Coude - Générique | Autre - Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Coude - Générique | Standard | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1377809 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.0167 m; Libellé de centre à extrémité: 0.025 m; Rayon du centre: 0.0249979 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000344046 m3; Taille: ø25 mm-ø25 mm; Taille maximale: 0.025 m; Taille minimale: 0.025 m; Rayon nominal: 0.0125 m; Diamètre nominal: 0.025 m; Diamètre extérieur du raccord: 0.0334 m; Taille de la coche: 0.01336 m; Centre à extrémité: 0.025 m; Angle: 90.0049 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 2.70005 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm-ø25 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Coude - Générique | Instance | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1377811 | Raccords de canalisation | Famille : Raccords de canalisation : Coude - Générique | Autre - Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
