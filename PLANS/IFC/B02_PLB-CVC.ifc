Properties of the parts of a building model (IFC4), part 4 of 10

# IfcBuildingElementPart (358)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
Coude - Générique | Standard | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1377984 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.0167 m; Libellé de centre à extrémité: 0.025 m; Rayon du centre: 0.025 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000344056 m3; Taille: ø25 mm-ø25 mm; Taille maximale: 0.025 m; Taille minimale: 0.025 m; Rayon nominal: 0.0125 m; Diamètre nominal: 0.025 m; Diamètre extérieur du raccord: 0.0334 m; Taille de la coche: 0.01336 m; Centre à extrémité: 0.025 m; Angle: 90 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 2.7 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm-ø25 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Coude - Générique | Standard | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1528549 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.038 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 4; Type de système: Eaux Usées; Cotes - Volume: 0.000109364 m3; Taille: ø40 mm-ø40 mm; Taille maximale: 0.04 m; Taille minimale: 0.04 m; Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 90 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.491037 m; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm-ø40 mm; Graphismes - Utiliser l'échelle d'annotations: yes
2 x Coude - Générique | Instance | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1379222 | Raccords de canalisation | Famille : Raccords de canalisation : Coude - Générique | Autre - Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Coude - Générique | Standard | Coude - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1528710 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord: 0.02415 m; Libellé de centre à extrémité: 0.038 m; Rayon du centre: 0.038 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Cotes - Volume: 0.000109364 m3; Taille: ø40 mm-ø40 mm; Taille maximale: 0.04 m; Taille minimale: 0.04 m; Rayon nominal: 0.02 m; Diamètre nominal: 0.04 m; Diamètre extérieur du raccord: 0.0483 m; Taille de la coche: 0.01932 m; Centre à extrémité: 0.038 m; Angle: 90 deg; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.491037 m; Type de Revit - Id: 642146; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Coude - Générique; Nom de la famille: Coude - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Regular 45, 90 and 180 Elbow; Nom de la table de consultation: Elbow - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm-ø40 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Transformation - Générique | Family | Transformation - Générique | N0 FINI
Transformation - Générique | Standard | Transformation - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345971 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord 1: 0.010209 m; Rayon extérieur du raccord 2: 0.012709 m; Diamètre nominal max. 12: 0.015 m; Décalage de la largeur: 3.048 m; Décalage de la hauteur: 3.048 m; Visibilité 1: no; Visibilité 2: no; Visibilité 3: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000326177 m3; Surface: 0.00385739 m2; Taille: ø15 mm-ø10 mm; Longueur: 0.0794453 m; Taille maximale: 0.015 m; Taille minimale: 0.01 m; Hauteur de décalage: 5.0000 mm; Largeur de décalage: 5.0000 mm; Rayon nominal 1: 0.005 m; Diamètre nominal 1: 0.01 m; Diamètre extérieur du raccord 1: 0.020418 m; Taille de la coche 1: 0.00816719 m; Rayon nominal 2: 0.0075 m; Diamètre nominal 2: 0.015 m; Diamètre extérieur du raccord 2: 0.025418 m; Taille de la coche 2: 0.0101672 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.720555 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 643819; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Transformation - Générique; Nom de la famille: Transformation - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser; Nom de la table de consultation: Transition - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø10 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Transformation - Générique | Instance | Transformation - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345975 | Raccords de canalisation | Famille : Raccords de canalisation : Transformation - Générique | Autre - Nom de la famille: Transformation - Générique; Nom de la table de consultation: Transition - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser
Transformation - Générique | Standard | Transformation - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1346065 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord 1: 0.012709 m; Rayon extérieur du raccord 2: 0.010209 m; Diamètre nominal max. 12: 0.015 m; Décalage de la largeur: 3.048 m; Décalage de la hauteur: 3.048 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000327615 m3; Surface: 0.00385739 m2; Taille: ø15 mm-ø10 mm; Longueur: 0.0794453 m; Taille maximale: 0.015 m; Taille minimale: 0.01 m; Hauteur de décalage: 7.5000 mm; Largeur de décalage: 7.5000 mm; Rayon nominal 1: 0.0075 m; Diamètre nominal 1: 0.015 m; Diamètre extérieur du raccord 1: 0.025418 m; Taille de la coche 1: 0.0101672 m; Rayon nominal 2: 0.005 m; Diamètre nominal 2: 0.01 m; Diamètre extérieur du raccord 2: 0.020418 m; Taille de la coche 2: 0.00816719 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.8 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 643819; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Transformation - Générique; Nom de la famille: Transformation - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser; Nom de la table de consultation: Transition - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø10 mm; Graphismes - Utiliser l'échelle d'annotations: yes
2 x Transformation - Générique | Instance | Transformation - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1346067 | Raccords de canalisation | Famille : Raccords de canalisation : Transformation - Générique | Autre - Nom de la famille: Transformation - Générique; Nom de la table de consultation: Transition - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser
Transformation - Générique | Standard | Transformation - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1346206 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord 1: 0.012709 m; Rayon extérieur du raccord 2: 0.010209 m; Diamètre nominal max. 12: 0.015 m; Décalage de la largeur: 3.048 m; Décalage de la hauteur: 3.048 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000327615 m3; Surface: 0.00385739 m2; Taille: ø15 mm-ø10 mm; Longueur: 0.0794453 m; Taille maximale: 0.015 m; Taille minimale: 0.01 m; Hauteur de décalage: 7.5000 mm; Largeur de décalage: 7.5000 mm; Rayon nominal 1: 0.0075 m; Diamètre nominal 1: 0.015 m; Diamètre extérieur du raccord 1: 0.025418 m; Taille de la coche 1: 0.0101672 m; Rayon nominal 2: 0.005 m; Diamètre nominal 2: 0.01 m; Diamètre extérieur du raccord 2: 0.020418 m; Taille de la coche 2: 0.00816719 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.8 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 643819; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Transformation - Générique; Nom de la famille: Transformation - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser; Nom de la table de consultation: Transition - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø10 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Transformation - Générique | Standard | Transformation - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1346293 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord 1: 0.0167 m; Rayon extérieur du raccord 2: 0.012709 m; Diamètre nominal max. 12: 0.025 m; Décalage de la largeur: 3.048 m; Décalage de la hauteur: 3.048 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000346997 m3; Surface: 0.00372677 m2; Taille: ø25 mm-ø15 mm; Longueur: 0.051 m; Taille maximale: 0.025 m; Taille minimale: 0.015 m; Hauteur de décalage: 12.5000 mm; Largeur de décalage: 12.5000 mm; Rayon nominal 1: 0.0125 m; Diamètre nominal 1: 0.025 m; Diamètre extérieur du raccord 1: 0.0334 m; Taille de la coche 1: 0.01336 m; Rayon nominal 2: 0.0075 m; Diamètre nominal 2: 0.015 m; Diamètre extérieur du raccord 2: 0.025418 m; Taille de la coche 2: 0.0101672 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 1.66196 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 643819; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Transformation - Générique; Nom de la famille: Transformation - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser; Nom de la table de consultation: Transition - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Transformation - Générique | Instance | Transformation - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1346299 | Raccords de canalisation | Famille : Raccords de canalisation : Transformation - Générique | Autre - Nom de la famille: Transformation - Générique; Nom de la table de consultation: Transition - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser
Transformation - Générique | Standard | Transformation - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1346295 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord 1: 0.0167 m; Rayon extérieur du raccord 2: 0.012709 m; Diamètre nominal max. 12: 0.025 m; Décalage de la largeur: 3.048 m; Décalage de la hauteur: 3.048 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000346997 m3; Surface: 0.00372677 m2; Taille: ø25 mm-ø15 mm; Longueur: 0.051 m; Taille maximale: 0.025 m; Taille minimale: 0.015 m; Hauteur de décalage: 12.5000 mm; Largeur de décalage: 12.5000 mm; Rayon nominal 1: 0.0125 m; Diamètre nominal 1: 0.025 m; Diamètre extérieur du raccord 1: 0.0334 m; Taille de la coche 1: 0.01336 m; Rayon nominal 2: 0.0075 m; Diamètre nominal 2: 0.015 m; Diamètre extérieur du raccord 2: 0.025418 m; Taille de la coche 2: 0.0101672 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 1.69996 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 643819; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Transformation - Générique; Nom de la famille: Transformation - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser; Nom de la table de consultation: Transition - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Transformation - Générique | Instance | Transformation - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1346300 | Raccords de canalisation | Famille : Raccords de canalisation : Transformation - Générique | Autre - Nom de la famille: Transformation - Générique; Nom de la table de consultation: Transition - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser
Transformation - Générique | Standard | Transformation - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1346297 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord 1: 0.0167 m; Rayon extérieur du raccord 2: 0.012709 m; Diamètre nominal max. 12: 0.025 m; Décalage de la largeur: 3.048 m; Décalage de la hauteur: 3.048 m; Visibilité 1: no; Visibilité 2: yes; Visibilité 3: no; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000346997 m3; Surface: 0.00372677 m2; Taille: ø25 mm-ø15 mm; Longueur: 0.051 m; Taille maximale: 0.025 m; Taille minimale: 0.015 m; Hauteur de décalage: 12.5000 mm; Largeur de décalage: 12.5000 mm; Rayon nominal 1: 0.0125 m; Diamètre nominal 1: 0.025 m; Diamètre extérieur du raccord 1: 0.0334 m; Taille de la coche 1: 0.01336 m; Rayon nominal 2: 0.0075 m; Diamètre nominal 2: 0.015 m; Diamètre extérieur du raccord 2: 0.025418 m; Taille de la coche 2: 0.0101672 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 1.66196 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 643819; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Transformation - Générique; Nom de la famille: Transformation - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser; Nom de la table de consultation: Transition - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Transformation - Générique | Instance | Transformation - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1346301 | Raccords de canalisation | Famille : Raccords de canalisation : Transformation - Générique | Autre - Nom de la famille: Transformation - Générique; Nom de la table de consultation: Transition - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser
Transformation - Générique | Standard | Transformation - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1528551 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord 1: 0.02415 m; Rayon extérieur du raccord 2: 0.02415 m; Diamètre nominal max. 12: 0.04 m; Décalage de la largeur: 3.05933 m; Décalage de la hauteur: 3.048 m; Visibilité 1: yes; Visibilité 2: no; Visibilité 3: no; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 4; Type de système: Eaux Usées; Cotes - Volume: 0.000117097 m3; Surface: 0.0088777 m2; Taille: ø40 mm-ø40 mm; Longueur: 0.064 m; Taille maximale: 0.04 m; Taille minimale: 0.04 m; Hauteur de décalage: 20.0000 mm; Largeur de décalage: 31.3304 mm; Rayon nominal 1: 0.02 m; Diamètre nominal 1: 0.04 m; Diamètre extérieur du raccord 1: 0.0483 m; Taille de la coche 1: 0.01932 m; Rayon nominal 2: 0.02 m; Diamètre nominal 2: 0.04 m; Diamètre extérieur du raccord 2: 0.0483 m; Taille de la coche 2: 0.01932 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.453151 m; Type de Revit - Id: 643819; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Transformation - Générique; Nom de la famille: Transformation - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser; Nom de la table de consultation: Transition - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm-ø40 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Transformation - Générique | Instance | Transformation - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1528543 | Raccords de canalisation | Famille : Raccords de canalisation : Transformation - Générique | Autre - Nom de la famille: Transformation - Générique; Nom de la table de consultation: Transition - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser
Transformation - Générique | Standard | Transformation - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1528712 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Rayon extérieur du raccord 1: 0.02415 m; Rayon extérieur du raccord 2: 0.02415 m; Diamètre nominal max. 12: 0.04 m; Décalage de la largeur: 3.05933 m; Décalage de la hauteur: 3.048 m; Visibilité 1: yes; Visibilité 2: no; Visibilité 3: no; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Cotes - Volume: 0.000117097 m3; Surface: 0.00887769 m2; Taille: ø40 mm-ø40 mm; Longueur: 0.064 m; Taille maximale: 0.04 m; Taille minimale: 0.04 m; Hauteur de décalage: 20.0000 mm; Largeur de décalage: 31.3301 mm; Rayon nominal 1: 0.02 m; Diamètre nominal 1: 0.04 m; Diamètre extérieur du raccord 1: 0.0483 m; Taille de la coche 1: 0.01932 m; Rayon nominal 2: 0.02 m; Diamètre nominal 2: 0.04 m; Diamètre extérieur du raccord 2: 0.0483 m; Taille de la coche 2: 0.01932 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.453152 m; Type de Revit - Id: 643819; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : Transformation - Générique; Nom de la famille: Transformation - Générique; Nom du type: Standard; Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser; Nom de la table de consultation: Transition - Generic; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm-ø40 mm; Graphismes - Utiliser l'échelle d'annotations: yes
Transformation - Générique | Instance | Transformation - Générique | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1528705 | Raccords de canalisation | Famille : Raccords de canalisation : Transformation - Générique | Autre - Nom de la famille: Transformation - Générique; Nom de la table de consultation: Transition - Generic; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Génie climatique - Méthode de perte de charge: 1; Tableau de coefficient K: Reducer/Coupling/Union/Increaser
RACCORD REDUCTEUR 15-10 | Family | RACCORD REDUCTEUR 15-10 | N0 FINI
RACCORD REDUCTEUR 15-10 | Type | RACCORD REDUCTEUR 15-10 | N0 FINI
RACCORD REDUCTEUR 15-10 | RACCORD REDUCTEUR 15-10 | RACCORD REDUCTEUR 15-10 | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1351742 | Raccords de canalisation | 2021_015 | Autre - Famille et type: RACCORD REDUCTEUR 15-10; Famille: RACCORD REDUCTEUR 15-10; Type: RACCORD REDUCTEUR 15-10; ID du type: RACCORD REDUCTEUR 15-10; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: TRANSITION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.00000102309 m3; Surface: 0.000781767 m2; Taille: ø15 mm-ø10 mm; Taille maximale: 0.015 m; Taille minimale: 0.01 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.5 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1350737; Nom: RACCORD REDUCTEUR 15-10; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : RACCORD REDUCTEUR 15-10; Nom de la famille: RACCORD REDUCTEUR 15-10; Nom du type: RACCORD REDUCTEUR 15-10; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø10 mm; Graphismes - Utiliser l'échelle d'annotations: yes
3 x RACCORD REDUCTEUR 15-10 | Instance | RACCORD REDUCTEUR 15-10 | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1350737 | Raccords de canalisation | Famille : Raccords de canalisation : RACCORD REDUCTEUR 15-10 | Autre - Nom de la famille: RACCORD REDUCTEUR 15-10; Données d'identification - Nom du type: RACCORD REDUCTEUR 15-10; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
RACCORD REDUCTEUR 15-10 | RACCORD REDUCTEUR 15-10 | RACCORD REDUCTEUR 15-10 | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1352687 | Raccords de canalisation | 2021_015 | Autre - Famille et type: RACCORD REDUCTEUR 15-10; Famille: RACCORD REDUCTEUR 15-10; Type: RACCORD REDUCTEUR 15-10; ID du type: RACCORD REDUCTEUR 15-10; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: TRANSITION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.00000102309 m3; Surface: 0.000781767 m2; Taille: ø15 mm-ø10 mm; Taille maximale: 0.015 m; Taille minimale: 0.01 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.499999 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1350737; Nom: RACCORD REDUCTEUR 15-10; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : RACCORD REDUCTEUR 15-10; Nom de la famille: RACCORD REDUCTEUR 15-10; Nom du type: RACCORD REDUCTEUR 15-10; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø10 mm; Graphismes - Utiliser l'échelle d'annotations: yes
RACCORD REDUCTEUR 15-10 | RACCORD REDUCTEUR 15-10 | RACCORD REDUCTEUR 15-10 | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1352750 | Raccords de canalisation | 2021_015 | Autre - Famille et type: RACCORD REDUCTEUR 15-10; Famille: RACCORD REDUCTEUR 15-10; Type: RACCORD REDUCTEUR 15-10; ID du type: RACCORD REDUCTEUR 15-10; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: TRANSITION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.00000102309 m3; Surface: 0.000781767 m2; Taille: ø15 mm-ø10 mm; Taille maximale: 0.015 m; Taille minimale: 0.01 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.499999 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1350737; Nom: RACCORD REDUCTEUR 15-10; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de canalisation : RACCORD REDUCTEUR 15-10; Nom de la famille: RACCORD REDUCTEUR 15-10; Nom du type: RACCORD REDUCTEUR 15-10; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø10 mm; Graphismes - Utiliser l'échelle d'annotations: yes
AliaxisFR_Hometech_ExternalReducer_FR | Family | AliaxisFR_Hometech_ExternalReducer_FR | N0 FINI
Variable | Type | Variable | N0 FINI
AliaxisFR_Hometech_ExternalReducer_FR | Variable | AliaxisFR_Hometech_ExternalReducer_FR | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1379188 | Raccords de canalisation | 2021_015 | Autre - Famille et type: Variable; Famille: Variable; Type: Variable; ID du type: Variable; IsCustom: yes; Not Flipped: yes; Flipped: no; Socket Flipped: no; Socket Not Flipped: no; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: TRANSITION; Exporter au format IFC sous: IfcPipeFittingType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Cotes - Volume: 0.000622388 m3; Taille: ø100 mm-ø40 mm; Taille maximale: 0.1 m; Taille minimale: 0.04 m; D2: 0.005 m; L1: 0.036 m; L2: 0.057 m; D: 0.093 m; D3: 0 m; D4: 0 m; Pipe Outer Diameter 1: 0.1 m; Pipe Outer Diameter 2: 0.04 m; Connector Diameter 2: 0.04 m; Connector Diameter 1: 0.1 m; Pipe Outer Diameter 3: 0.02 m; L3: 0.027 m; Connector 1: 0.1 m; Connector 2: 0.04 m; L5: 0.03 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.0902254 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 1083956; Nom: Variable; Elévation par défaut: 0 m; Catégorie: Raccords de canalisation; Exporter le type au format IFC: 0; Fabricant: Aliaxis France; Sous-projet: Famille : Raccords de canalisation : AliaxisFR_Hometech_ExternalReducer_FR; Nom de la famille: AliaxisFR_Hometech_ExternalReducer_FR; Nom du type: Variable; Material: PVC Grey; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø100 mm-ø40 mm; Graphismes - Utiliser l'échelle d'annotations: yes; Données d'identification - Article Nr: Custom Fitting; Construction - Eccentric: no; Socket Visibility: no; Texte - Lookup Table Name 1: Hometech_ExternalReducer
AliaxisFR_Hometech_ExternalReducer_FR | Instance | AliaxisFR_Hometech_ExternalReducer_FR | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1379190 | Raccords de canalisation | Famille : Raccords de canalisation : AliaxisFR_Hometech_ExternalReducer_FR | Autre - Nom de la famille: AliaxisFR_Hometech_ExternalReducer_FR; Données d'identification - Fabricant: Aliaxis France; Nom du type: Variable; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Matériaux et finitions - Material: PVC Grey
Accessoire de canalisation | Category | Accessoire de canalisation | N0 FINI
STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | Family | STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | N0 FINI
CHICAGO Palanca Azul H-H | Type | CHICAGO Palanca Azul H-H | N0 FINI
STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | CHICAGO Palanca Azul H-H | STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345095 | Accessoire de canalisation | 2021_015 | Autre - Famille et type: CHICAGO Palanca Azul H-H; Famille: CHICAGO Palanca Azul H-H; Type: CHICAGO Palanca Azul H-H; ID du type: CHICAGO Palanca Azul H-H; CRP: 10004; C1: 4; C2: 1; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FAUCET; Exporter au format IFC sous: IfcValveType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000392733 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; D2: 0.0135 m; DN: 0.015 m; RN: 0.0075 m; DN (pulgadas): 1/2''; A: 0.046 m; B: 0.095 m; h: 0.046 m; h1: 0.0328 m; D1: 0.031 m; R1: 0.0155 m; A1: 0.01156 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.584498 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 921729; Nom: CHICAGO Palanca Azul H-H; Elévation par défaut: 0 m; Catégorie: Accessoire de canalisation; Exporter le type au format IFC: 0; Modèle: Válvula de esfera roscar CHICAGO palanca H-H; Fabricant: STH STANDARD HIDRAULICA; URL: http://www.standardhidraulica.com/; Description: Válvula de esfera roscar CHICAGO palanca H-H. Adecuada para agua fría, ACS y aire. Zonas en contacto con el fluido, no cromado. Producto básico y funcional; Titre OmniClass: Adjusting/Controlling Valves for Liquid Services; Numéro OmniClass: 23.65.55.14.17; Sous-projet: Famille : Accessoire de canalisation : STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom de la famille: STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom du type: CHICAGO Palanca Azul H-H; Type: Type prédéfini d'IFC: CHECK; Exporter le type au format IFC sous: IfcValveType; IfcExportAs: IfcValveType; IfcExportType: CHECK; Coefficient K: 0; Normativa UNE (accesorios): UNE-EN 12.164-12.165; BIMETRICAL Category: Valve; Versión Familia: 1.0; Versión Revit: Revit 2016 - Español; Fecha de Revisión: 09/2017; Creado por: BIMETRICAL; BIMETRICAL: http://www.bimetrical.com/; Nombre_Lookup_Cotas: STH Valvula Esfera Palanca H-H CHICAGO - Cotas; PN: PN 25; Temperatura: -10 ºC a 110 ºC; Nombre_Lookup_Referencia: STH Valvula Esfera Palanca H-H CHICAGO - Referencia; Material cuerpo: STH_Latón Acabado Niquelado; Material palanca: STH_Aluminio; G: 0.008 m; Color palanca: STH_Palanca Azul; G1: 0.0073 m; Palanca Azul: yes; Palanca Roja: no; Génie climatique - Débit - Perte de pression: 0.0 Pa; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes; Données d'identification - Referencia Producto: 34501; Código: 34501
6 x STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | Instance | STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 922235 | Accessoire de canalisation | Famille : Accessoire de canalisation : STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | Autre - Nom de la famille: STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nombre_Lookup_Cotas: STH Valvula Esfera Palanca H-H CHICAGO - Cotas; Nombre_Lookup_Referencia: STH Valvula Esfera Palanca H-H CHICAGO - Referencia; Données d'identification - Modèle: Válvula de esfera roscar CHICAGO palanca H-H; Fabricant: STH STANDARD HIDRAULICA; URL: http://www.standardhidraulica.com/; Description: Válvula de esfera roscar CHICAGO palanca H-H. Adecuada para agua fría, ACS y aire. Zonas en contacto con el fluido, no cromado. Producto básico y funcional; Titre OmniClass: Adjusting/Controlling Valves for Liquid Services; Numéro OmniClass: 23.65.55.14.17; Nom du type: CHICAGO Palanca Azul H-H; Normativa UNE (accesorios): UNE-EN 12.164-12.165; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: CHECK; Exporter le type au format IFC sous: IfcValveType; IfcExportAs: IfcValveType; IfcExportType: CHECK; BIMETRICAL Category: Valve; Versión Familia: 1.0; Versión Revit: Revit 2016 - Español; Fecha de Revisión: 09/2017; Creado por: BIMETRICAL; BIMETRICAL: http://www.bimetrical.com/; Génie climatique - Coefficient K: 0; Données - PN: PN 25; Temperatura: -10 ºC a 110 ºC; Palanca Azul: yes; Palanca Roja: no; Matériaux et finitions - Material cuerpo: STH_Latón Acabado Niquelado; Material palanca: STH_Aluminio; Color palanca: STH_Palanca Azul; Cotes - G: 0.008 m; G1: 0.0073 m
STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | CHICAGO Palanca Azul H-H | STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345119 | Accessoire de canalisation | 2021_015 | Autre - Famille et type: CHICAGO Palanca Azul H-H; Famille: CHICAGO Palanca Azul H-H; Type: CHICAGO Palanca Azul H-H; ID du type: CHICAGO Palanca Azul H-H; CRP: 10004; C1: 4; C2: 1; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FAUCET; Exporter au format IFC sous: IfcValveType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000392733 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; D2: 0.0135 m; DN: 0.015 m; RN: 0.0075 m; DN (pulgadas): 1/2''; A: 0.046 m; B: 0.095 m; h: 0.046 m; h1: 0.0328 m; D1: 0.031 m; R1: 0.0155 m; A1: 0.01156 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.589499 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 921729; Nom: CHICAGO Palanca Azul H-H; Elévation par défaut: 0 m; Catégorie: Accessoire de canalisation; Exporter le type au format IFC: 0; Modèle: Válvula de esfera roscar CHICAGO palanca H-H; Fabricant: STH STANDARD HIDRAULICA; URL: http://www.standardhidraulica.com/; Description: Válvula de esfera roscar CHICAGO palanca H-H. Adecuada para agua fría, ACS y aire. Zonas en contacto con el fluido, no cromado. Producto básico y funcional; Titre OmniClass: Adjusting/Controlling Valves for Liquid Services; Numéro OmniClass: 23.65.55.14.17; Sous-projet: Famille : Accessoire de canalisation : STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom de la famille: STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom du type: CHICAGO Palanca Azul H-H; Type: Type prédéfini d'IFC: CHECK; Exporter le type au format IFC sous: IfcValveType; IfcExportAs: IfcValveType; IfcExportType: CHECK; Coefficient K: 0; Normativa UNE (accesorios): UNE-EN 12.164-12.165; BIMETRICAL Category: Valve; Versión Familia: 1.0; Versión Revit: Revit 2016 - Español; Fecha de Revisión: 09/2017; Creado por: BIMETRICAL; BIMETRICAL: http://www.bimetrical.com/; Nombre_Lookup_Cotas: STH Valvula Esfera Palanca H-H CHICAGO - Cotas; PN: PN 25; Temperatura: -10 ºC a 110 ºC; Nombre_Lookup_Referencia: STH Valvula Esfera Palanca H-H CHICAGO - Referencia; Material cuerpo: STH_Latón Acabado Niquelado; Material palanca: STH_Aluminio; G: 0.008 m; Color palanca: STH_Palanca Azul; G1: 0.0073 m; Palanca Azul: yes; Palanca Roja: no; Génie climatique - Débit - Perte de pression: 0.0 Pa; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes; Données d'identification - Referencia Producto: 34501; Código: 34501
STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | CHICAGO Palanca Azul H-H | STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1345147 | Accessoire de canalisation | 2021_015 | Autre - Famille et type: CHICAGO Palanca Azul H-H; Famille: CHICAGO Palanca Azul H-H; Type: CHICAGO Palanca Azul H-H; ID du type: CHICAGO Palanca Azul H-H; CRP: 10004; C1: 4; C2: 1; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FAUCET; Exporter au format IFC sous: IfcValveType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000392733 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; D2: 0.0135 m; DN: 0.015 m; RN: 0.0075 m; DN (pulgadas): 1/2''; A: 0.046 m; B: 0.095 m; h: 0.046 m; h1: 0.0328 m; D1: 0.031 m; R1: 0.0155 m; A1: 0.01156 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.602499 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 921729; Nom: CHICAGO Palanca Azul H-H; Elévation par défaut: 0 m; Catégorie: Accessoire de canalisation; Exporter le type au format IFC: 0; Modèle: Válvula de esfera roscar CHICAGO palanca H-H; Fabricant: STH STANDARD HIDRAULICA; URL: http://www.standardhidraulica.com/; Description: Válvula de esfera roscar CHICAGO palanca H-H. Adecuada para agua fría, ACS y aire. Zonas en contacto con el fluido, no cromado. Producto básico y funcional; Titre OmniClass: Adjusting/Controlling Valves for Liquid Services; Numéro OmniClass: 23.65.55.14.17; Sous-projet: Famille : Accessoire de canalisation : STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom de la famille: STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom du type: CHICAGO Palanca Azul H-H; Type: Type prédéfini d'IFC: CHECK; Exporter le type au format IFC sous: IfcValveType; IfcExportAs: IfcValveType; IfcExportType: CHECK; Coefficient K: 0; Normativa UNE (accesorios): UNE-EN 12.164-12.165; BIMETRICAL Category: Valve; Versión Familia: 1.0; Versión Revit: Revit 2016 - Español; Fecha de Revisión: 09/2017; Creado por: BIMETRICAL; BIMETRICAL: http://www.bimetrical.com/; Nombre_Lookup_Cotas: STH Valvula Esfera Palanca H-H CHICAGO - Cotas; PN: PN 25; Temperatura: -10 ºC a 110 ºC; Nombre_Lookup_Referencia: STH Valvula Esfera Palanca H-H CHICAGO - Referencia; Material cuerpo: STH_Latón Acabado Niquelado; Material palanca: STH_Aluminio; G: 0.008 m; Color palanca: STH_Palanca Azul; G1: 0.0073 m; Palanca Azul: yes; Palanca Roja: no; Génie climatique - Débit - Perte de pression: 0.0 Pa; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes; Données d'identification - Referencia Producto: 34501; Código: 34501
STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | CHICAGO Palanca Azul H-H | STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1348018 | Accessoire de canalisation | 2021_015 | Autre - Famille et type: CHICAGO Palanca Azul H-H; Famille: CHICAGO Palanca Azul H-H; Type: CHICAGO Palanca Azul H-H; ID du type: CHICAGO Palanca Azul H-H; CRP: 10016; C1: 16; C2: 1; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FAUCET; Exporter au format IFC sous: IfcValveType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000816793 m3; Taille: ø25 mm-ø25 mm; Taille maximale: 0.025 m; Taille minimale: 0.025 m; D2: 0.0135 m; DN: 0.025 m; RN: 0.0125 m; DN (pulgadas): 1''; A: 0.061 m; B: 0.104 m; h: 0.057 m; h1: 0.0415 m; D1: 0.041 m; R1: 0.0205 m; A1: 0.01456 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 1.69996 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 921729; Nom: CHICAGO Palanca Azul H-H; Elévation par défaut: 0 m; Catégorie: Accessoire de canalisation; Exporter le type au format IFC: 0; Modèle: Válvula de esfera roscar CHICAGO palanca H-H; Fabricant: STH STANDARD HIDRAULICA; URL: http://www.standardhidraulica.com/; Description: Válvula de esfera roscar CHICAGO palanca H-H. Adecuada para agua fría, ACS y aire. Zonas en contacto con el fluido, no cromado. Producto básico y funcional; Titre OmniClass: Adjusting/Controlling Valves for Liquid Services; Numéro OmniClass: 23.65.55.14.17; Sous-projet: Famille : Accessoire de canalisation : STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom de la famille: STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom du type: CHICAGO Palanca Azul H-H; Type: Type prédéfini d'IFC: CHECK; Exporter le type au format IFC sous: IfcValveType; IfcExportAs: IfcValveType; IfcExportType: CHECK; Coefficient K: 0; Normativa UNE (accesorios): UNE-EN 12.164-12.165; BIMETRICAL Category: Valve; Versión Familia: 1.0; Versión Revit: Revit 2016 - Español; Fecha de Revisión: 09/2017; Creado por: BIMETRICAL; BIMETRICAL: http://www.bimetrical.com/; Nombre_Lookup_Cotas: STH Valvula Esfera Palanca H-H CHICAGO - Cotas; PN: PN 25; Temperatura: -10 ºC a 110 ºC; Nombre_Lookup_Referencia: STH Valvula Esfera Palanca H-H CHICAGO - Referencia; Material cuerpo: STH_Latón Acabado Niquelado; Material palanca: STH_Aluminio; G: 0.008 m; Color palanca: STH_Palanca Azul; G1: 0.0073 m; Palanca Azul: yes; Palanca Roja: no; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø25 mm-ø25 mm; Graphismes - Utiliser l'échelle d'annotations: yes; Données d'identification - Referencia Producto: 34503; Código: 34503
2 x STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | Instance | STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1348020 | Accessoire de canalisation | Famille : Accessoire de canalisation : STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | Autre - Nom de la famille: STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nombre_Lookup_Cotas: STH Valvula Esfera Palanca H-H CHICAGO - Cotas; Nombre_Lookup_Referencia: STH Valvula Esfera Palanca H-H CHICAGO - Referencia; Données d'identification - Modèle: Válvula de esfera roscar CHICAGO palanca H-H; Fabricant: STH STANDARD HIDRAULICA; URL: http://www.standardhidraulica.com/; Description: Válvula de esfera roscar CHICAGO palanca H-H. Adecuada para agua fría, ACS y aire. Zonas en contacto con el fluido, no cromado. Producto básico y funcional; Titre OmniClass: Adjusting/Controlling Valves for Liquid Services; Numéro OmniClass: 23.65.55.14.17; Nom du type: CHICAGO Palanca Azul H-H; Normativa UNE (accesorios): UNE-EN 12.164-12.165; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: CHECK; Exporter le type au format IFC sous: IfcValveType; IfcExportAs: IfcValveType; IfcExportType: CHECK; BIMETRICAL Category: Valve; Versión Familia: 1.0; Versión Revit: Revit 2016 - Español; Fecha de Revisión: 09/2017; Creado por: BIMETRICAL; BIMETRICAL: http://www.bimetrical.com/; Génie climatique - Coefficient K: 0; Données - PN: PN 25; Temperatura: -10 ºC a 110 ºC; Palanca Azul: yes; Palanca Roja: no; Matériaux et finitions - Material cuerpo: STH_Latón Acabado Niquelado; Material palanca: STH_Aluminio; Color palanca: STH_Palanca Azul; Cotes - G: 0.008 m; G1: 0.0073 m
STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | CHICAGO Palanca Azul H-H | STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1349231 | Accessoire de canalisation | 2021_015 | Autre - Famille et type: CHICAGO Palanca Azul H-H; Famille: CHICAGO Palanca Azul H-H; Type: CHICAGO Palanca Azul H-H; ID du type: CHICAGO Palanca Azul H-H; CRP: 10004; C1: 4; C2: 1; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FAUCET; Exporter au format IFC sous: IfcValveType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000392733 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; D2: 0.0135 m; DN: 0.015 m; RN: 0.0075 m; DN (pulgadas): 1/2''; A: 0.046 m; B: 0.095 m; h: 0.046 m; h1: 0.0328 m; D1: 0.031 m; R1: 0.0155 m; A1: 0.01156 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.5 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 921729; Nom: CHICAGO Palanca Azul H-H; Elévation par défaut: 0 m; Catégorie: Accessoire de canalisation; Exporter le type au format IFC: 0; Modèle: Válvula de esfera roscar CHICAGO palanca H-H; Fabricant: STH STANDARD HIDRAULICA; URL: http://www.standardhidraulica.com/; Description: Válvula de esfera roscar CHICAGO palanca H-H. Adecuada para agua fría, ACS y aire. Zonas en contacto con el fluido, no cromado. Producto básico y funcional; Titre OmniClass: Adjusting/Controlling Valves for Liquid Services; Numéro OmniClass: 23.65.55.14.17; Sous-projet: Famille : Accessoire de canalisation : STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom de la famille: STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom du type: CHICAGO Palanca Azul H-H; Type: Type prédéfini d'IFC: CHECK; Exporter le type au format IFC sous: IfcValveType; IfcExportAs: IfcValveType; IfcExportType: CHECK; Coefficient K: 0; Normativa UNE (accesorios): UNE-EN 12.164-12.165; BIMETRICAL Category: Valve; Versión Familia: 1.0; Versión Revit: Revit 2016 - Español; Fecha de Revisión: 09/2017; Creado por: BIMETRICAL; BIMETRICAL: http://www.bimetrical.com/; Nombre_Lookup_Cotas: STH Valvula Esfera Palanca H-H CHICAGO - Cotas; PN: PN 25; Temperatura: -10 ºC a 110 ºC; Nombre_Lookup_Referencia: STH Valvula Esfera Palanca H-H CHICAGO - Referencia; Material cuerpo: STH_Latón Acabado Niquelado; Material palanca: STH_Aluminio; G: 0.008 m; Color palanca: STH_Palanca Azul; G1: 0.0073 m; Palanca Azul: yes; Palanca Roja: no; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes; Données d'identification - Referencia Producto: 34501; Código: 34501
STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | CHICAGO Palanca Azul H-H | STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1349247 | Accessoire de canalisation | 2021_015 | Autre - Famille et type: CHICAGO Palanca Azul H-H; Famille: CHICAGO Palanca Azul H-H; Type: CHICAGO Palanca Azul H-H; ID du type: CHICAGO Palanca Azul H-H; CRP: 10004; C1: 4; C2: 1; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FAUCET; Exporter au format IFC sous: IfcValveType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Cotes - Volume: 0.0000392733 m3; Taille: ø15 mm-ø15 mm; Taille maximale: 0.015 m; Taille minimale: 0.015 m; D2: 0.0135 m; DN: 0.015 m; RN: 0.0075 m; DN (pulgadas): 1/2''; A: 0.046 m; B: 0.095 m; h: 0.046 m; h1: 0.0328 m; D1: 0.031 m; R1: 0.0155 m; A1: 0.01156 m; Phase de construction - Phase de création: Existant; Contraintes - Niveau: N0 FINI; Élévation par rapport au niveau: 0.499999 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 921729; Nom: CHICAGO Palanca Azul H-H; Elévation par défaut: 0 m; Catégorie: Accessoire de canalisation; Exporter le type au format IFC: 0; Modèle: Válvula de esfera roscar CHICAGO palanca H-H; Fabricant: STH STANDARD HIDRAULICA; URL: http://www.standardhidraulica.com/; Description: Válvula de esfera roscar CHICAGO palanca H-H. Adecuada para agua fría, ACS y aire. Zonas en contacto con el fluido, no cromado. Producto básico y funcional; Titre OmniClass: Adjusting/Controlling Valves for Liquid Services; Numéro OmniClass: 23.65.55.14.17; Sous-projet: Famille : Accessoire de canalisation : STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom de la famille: STH_VALVULA_ESFERA_PALANCA_H-H_CHICAGO.RFA; Nom du type: CHICAGO Palanca Azul H-H; Type: Type prédéfini d'IFC: CHECK; Exporter le type au format IFC sous: IfcValveType; IfcExportAs: IfcValveType; IfcExportType: CHECK; Coefficient K: 0; Normativa UNE (accesorios): UNE-EN 12.164-12.165; BIMETRICAL Category: Valve; Versión Familia: 1.0; Versión Revit: Revit 2016 - Español; Fecha de Revisión: 09/2017; Creado por: BIMETRICAL; BIMETRICAL: http://www.bimetrical.com/; Nombre_Lookup_Cotas: STH Valvula Esfera Palanca H-H CHICAGO - Cotas; PN: PN 25; Temperatura: -10 ºC a 110 ºC; Nombre_Lookup_Referencia: STH Valvula Esfera Palanca H-H CHICAGO - Referencia; Material cuerpo: STH_Latón Acabado Niquelado; Material palanca: STH_Aluminio; G: 0.008 m; Color palanca: STH_Palanca Azul; G1: 0.0073 m; Palanca Azul: yes; Palanca Roja: no; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm-ø15 mm; Graphismes - Utiliser l'échelle d'annotations: yes; Données d'identification - Referencia Producto: 34501; Código: 34501
