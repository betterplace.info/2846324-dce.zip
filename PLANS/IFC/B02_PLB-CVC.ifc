Properties of the parts of a building model (IFC4), part 7 of 10

# IfcBuildingElementPart (358)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
Gaine flexible circulaire | Souple - Circulaire | Gaine flexible circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513628 | Gaine flexible | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 142444; Nom: Souple - Circulaire; Catégorie: Gaine flexible; Exporter le type au format IFC: 0; Sous-projet: Gaine flexible; Nom de la famille: Gaine flexible circulaire; Nom du type: Souple - Circulaire; Rugosité: 0.00009144 m; Type de jonction préférée: 1; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 2; Trajectoire critique: no; Diamètre hydraulique: 0.08 m; Contraintes - Élévation centrale de départ: 2.6 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø80 mm; Cotes - Longueur: 0.280943 m; Diamètre: 0.08 m; Graphismes - Modèle de gaine flexible: 0; Revizto - Mechanical: yes; Revêtement - Taille libre: ø80 mm; Epaisseur du revêtement: 0 m
Gaine flexible circulaire | Souple - Circulaire | Gaine flexible circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513723 | Gaine flexible | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 3; Type de système: Reprise; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 142444; Nom: Souple - Circulaire; Catégorie: Gaine flexible; Exporter le type au format IFC: 0; Sous-projet: Gaine flexible; Nom de la famille: Gaine flexible circulaire; Nom du type: Souple - Circulaire; Rugosité: 0.00009144 m; Type de jonction préférée: 1; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0.001143; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Trajectoire critique: no; Diamètre hydraulique: 0.08 m; Contraintes - Élévation centrale de départ: 2.5295 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø80 mm; Cotes - Longueur: 0.204903 m; Diamètre: 0.08 m; Graphismes - Modèle de gaine flexible: 0; Revizto - Mechanical: yes; Revêtement - Taille libre: ø80 mm; Epaisseur du revêtement: 0 m
Gaine flexible circulaire | Souple - Circulaire | Gaine flexible circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513726 | Gaine flexible | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 142444; Nom: Souple - Circulaire; Catégorie: Gaine flexible; Exporter le type au format IFC: 0; Sous-projet: Gaine flexible; Nom de la famille: Gaine flexible circulaire; Nom du type: Souple - Circulaire; Rugosité: 0.00009144 m; Type de jonction préférée: 1; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 3; Trajectoire critique: no; Diamètre hydraulique: 0.08 m; Contraintes - Élévation centrale de départ: 2.5295 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø80 mm; Cotes - Longueur: 0.388408 m; Diamètre: 0.08 m; Graphismes - Modèle de gaine flexible: 0; Revizto - Mechanical: yes; Revêtement - Taille libre: ø80 mm; Epaisseur du revêtement: 0 m
Gaine flexible circulaire | Souple - Circulaire | Gaine flexible circulaire | N0 FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1513729 | Gaine flexible | 2021_015 | Autre - Famille et type: Souple - Circulaire; Famille: Souple - Circulaire; Type: Souple - Circulaire; ID du type: Souple - Circulaire; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: FLEXIBLESEGMENT; Exporter au format IFC sous: IfcDuctSegmentType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Reprise; Nom du système: Génie climatique Reprise 2; Type de système: Reprise; Verrouillage de la taille: no; Phase de construction - Phase de création: Existant; Type de Revit - Id: 142444; Nom: Souple - Circulaire; Catégorie: Gaine flexible; Exporter le type au format IFC: 0; Sous-projet: Gaine flexible; Nom de la famille: Gaine flexible circulaire; Nom du type: Souple - Circulaire; Rugosité: 0.00009144 m; Type de jonction préférée: 1; Génie climatique - Débit - Débit: 0.0 m³/h; Pression dynamique: 0.0 Pa; Débit supplémentaire: 0.0 m³/h; Nombre de Reynolds: 0; Rugosité relative: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 2; Trajectoire critique: no; Diamètre hydraulique: 0.08 m; Contraintes - Élévation centrale de départ: 2.5295 m; Niveau de référence: N0 FINI; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø80 mm; Cotes - Longueur: 0.334168 m; Diamètre: 0.08 m; Graphismes - Modèle de gaine flexible: 0; Revizto - Mechanical: yes; Revêtement - Taille libre: ø80 mm; Epaisseur du revêtement: 0 m
Appareils sanitaires | Category | Appareils sanitaires | <NoLevel>
POR_Matura_P2430_BIM_FR | Family | POR_Matura_P2430_BIM_FR | <NoLevel>
P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC | Type | P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC | <NoLevel>
POR_Matura_P2430_BIM_FR | P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC | POR_Matura_P2430_BIM_FR | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 1335246 | Appareils sanitaires | 2021_015 | Autre - Famille et type: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Famille: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Type: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; ID du type: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WCSEAT; Exporter au format IFC sous: IfcSanitaryTerminalType; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Cotes - Volume: 0.0293916 m3; Surface: 0.512996 m2; Phase de construction - Phase de création: Existant; Contraintes - Hôte: <non associé>; Élévation par rapport au niveau: 0 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 716556; Nom: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Elévation par défaut: 0.4 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: P243001; Fabricant: sav@idealstandard.com; URL: www.idealspec.fr; Description: Matura Cuv Susp Rallongee 70 Blanc; Titre OmniClass: Water Operated Water Closets; Numéro OmniClass: 23.45.05.21.11.11; Description de l'assemblage: Bath & Toilet Accessories; Code d'assemblage: C1030200; Sous-projet: Famille : Appareils sanitaires : POR_Matura_P2430_BIM_FR; Nom de la famille: POR_Matura_P2430_BIM_FR; Nom du type: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Commentaires du type: n/a; Finition: Blanc; Raccordement: Plomberie; Hauteur: 0.384201 m; Profondeur: 0.699915 m; Type: Type prédéfini d'IFC: WCPANS; Exporter le type au format IFC sous: IfcSanitaryType; Coût: 0.00; Accessoires: www.idealspec.fr; Caractéristiques: Cuvette suspendue rallongées Matura- P243001/ Porcher; CodeBarre: n/a; Composants: n/a; Conformité: NF; ConseilsDInstallation: www.idealspec.fr; ContactGarantieDesPièces: sav@idealstandard.com; Couleur: Blanc; CoûtDeRemplacement: 0; DateDeCréation: 2016-11-11; DébitL/Mn: 0; DétailGarantie: Constructeur; Dimensions: 700 x 355 x 385 mm; DuréeDeGarantieDesPièces: 2; DuréeDeGarantieDeTravail: n/a; DuréeDeVie: n/a; DuréeGarantie: ans; EffectuéPar: n/a; Espace: Interne; Forme: Complexe; GarantieDeTravail: n/a; Grade: n/a; LienUtile: sav@idealstandard.com; Marque: PORCHER; Matériel: Céramique; PerformanceAccessibilité: NF; PerformanceDeDurabilité: n/a; PiècesDétachées: sav@idealstandard.com; PoidsBrut: n/a; PoidsNet: 22 kg; Téléphone: 01.49.38.28.00; TypeDImmobilisation: Fixe; UnitéDeMesure: mm; UnitéDeTemps: an; UnitéMonétaire: n/a; ZoneDeMesure: n/a; IfcExportAs: IfcSanitaryType; IfcExportType: WCPANS; Auteur: www.idealstandardinternational.com; Bim-NomDuProjet: POR_Porcher_WcSystems_Matura_P243001; InformationsProduit: www.idealspec.fr; Révision: 1; Uniclass2015Code: Ss_40_15_90_97; Uniclass2015Title: WC systems; Uniclass2015Version: Products v1.1; UrlDuFabricant: www.idealspec.fr; Largeur: 0.354563 m; Longueur: 0.699915 m; WFU: 0; HWFU: 0; CWFU: 0; Version: 1; TypeDeCuvette: n/a; TypeDeWc: 0
3 x POR_Matura_P2430_BIM_FR | Instance | POR_Matura_P2430_BIM_FR | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 716556 | Appareils sanitaires | Famille : Appareils sanitaires : POR_Matura_P2430_BIM_FR | Autre - Nom de la famille: POR_Matura_P2430_BIM_FR; Accessoires: www.idealspec.fr; Caractéristiques: Cuvette suspendue rallongées Matura- P243001/ Porcher; CodeBarre: n/a; Composants: n/a; Conformité: NF; ConseilsDInstallation: www.idealspec.fr; ContactGarantieDesPièces: sav@idealstandard.com; Couleur: Blanc; CoûtDeRemplacement: 0; DateDeCréation: 2016-11-11; DébitL/Mn: 0; DétailGarantie: Constructeur; Dimensions: 700 x 355 x 385 mm; DuréeDeGarantieDesPièces: 2; DuréeDeGarantieDeTravail: n/a; DuréeDeVie: n/a; DuréeGarantie: ans; EffectuéPar: n/a; Espace: Interne; Finition: Blanc; Forme: Complexe; GarantieDeTravail: n/a; Grade: n/a; LienUtile: sav@idealstandard.com; Marque: PORCHER; Matériel: Céramique; Nom: WcSystems_Matura_P243001_Porcher; PerformanceAccessibilité: NF; PerformanceDeDurabilité: n/a; PiècesDétachées: sav@idealstandard.com; PoidsBrut: n/a; PoidsNet: 22 kg; Raccordement: Plomberie; Téléphone: 01.49.38.28.00; TypeDImmobilisation: Fixe; UnitéDeMesure: mm; UnitéDeTemps: an; UnitéMonétaire: n/a; ZoneDeMesure: n/a; Hauteur: 0.384201 m; Largeur: 0.354563 m; Longueur: 0.699915 m; Profondeur: 0.699915 m; Version: 1; Données d'identification - Modèle: P243001; Fabricant: sav@idealstandard.com; URL: www.idealspec.fr; Description: Matura Cuv Susp Rallongee 70 Blanc; Titre OmniClass: Water Operated Water Closets; Numéro OmniClass: 23.45.05.21.11.11; Description de l'assemblage: Bath & Toilet Accessories; Code d'assemblage: C1030200; Nom du type: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Note d'identification: 100_PLOMBERIE SANITAIRES; Commentaires du type: n/a; Coût: 0.00; Contraintes - Elévation par défaut: 0.4 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: WCPANS; Exporter le type au format IFC sous: IfcSanitaryType; IfcExportAs: IfcSanitaryType; IfcExportType: WCPANS; TypeDeCuvette: n/a; TypeDeWc: 0; Général - Auteur: www.idealstandardinternational.com; Bim-NomDuProjet: POR_Porcher_WcSystems_Matura_P243001; InformationsProduit: www.idealspec.fr; Révision: 1; Uniclass2015Code: Ss_40_15_90_97; Uniclass2015Title: WC systems; Uniclass2015Version: Products v1.1; UrlDuFabricant: www.idealspec.fr; Génie climatique - WFU: 0; HWFU: 0; CWFU: 0
POR_Matura_P2430_BIM_FR | P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC | POR_Matura_P2430_BIM_FR | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 1335248 | Appareils sanitaires | 2021_015 | Autre - Famille et type: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Famille: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Type: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; ID du type: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WCSEAT; Exporter au format IFC sous: IfcSanitaryTerminalType; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Cotes - Volume: 0.0293916 m3; Surface: 0.512996 m2; Phase de construction - Phase de création: Existant; Contraintes - Hôte: <non associé>; Élévation par rapport au niveau: 0 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 716556; Nom: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Elévation par défaut: 0.4 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: P243001; Fabricant: sav@idealstandard.com; URL: www.idealspec.fr; Description: Matura Cuv Susp Rallongee 70 Blanc; Titre OmniClass: Water Operated Water Closets; Numéro OmniClass: 23.45.05.21.11.11; Description de l'assemblage: Bath & Toilet Accessories; Code d'assemblage: C1030200; Sous-projet: Famille : Appareils sanitaires : POR_Matura_P2430_BIM_FR; Nom de la famille: POR_Matura_P2430_BIM_FR; Nom du type: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Commentaires du type: n/a; Finition: Blanc; Raccordement: Plomberie; Hauteur: 0.384201 m; Profondeur: 0.699915 m; Type: Type prédéfini d'IFC: WCPANS; Exporter le type au format IFC sous: IfcSanitaryType; Coût: 0.00; Accessoires: www.idealspec.fr; Caractéristiques: Cuvette suspendue rallongées Matura- P243001/ Porcher; CodeBarre: n/a; Composants: n/a; Conformité: NF; ConseilsDInstallation: www.idealspec.fr; ContactGarantieDesPièces: sav@idealstandard.com; Couleur: Blanc; CoûtDeRemplacement: 0; DateDeCréation: 2016-11-11; DébitL/Mn: 0; DétailGarantie: Constructeur; Dimensions: 700 x 355 x 385 mm; DuréeDeGarantieDesPièces: 2; DuréeDeGarantieDeTravail: n/a; DuréeDeVie: n/a; DuréeGarantie: ans; EffectuéPar: n/a; Espace: Interne; Forme: Complexe; GarantieDeTravail: n/a; Grade: n/a; LienUtile: sav@idealstandard.com; Marque: PORCHER; Matériel: Céramique; PerformanceAccessibilité: NF; PerformanceDeDurabilité: n/a; PiècesDétachées: sav@idealstandard.com; PoidsBrut: n/a; PoidsNet: 22 kg; Téléphone: 01.49.38.28.00; TypeDImmobilisation: Fixe; UnitéDeMesure: mm; UnitéDeTemps: an; UnitéMonétaire: n/a; ZoneDeMesure: n/a; IfcExportAs: IfcSanitaryType; IfcExportType: WCPANS; Auteur: www.idealstandardinternational.com; Bim-NomDuProjet: POR_Porcher_WcSystems_Matura_P243001; InformationsProduit: www.idealspec.fr; Révision: 1; Uniclass2015Code: Ss_40_15_90_97; Uniclass2015Title: WC systems; Uniclass2015Version: Products v1.1; UrlDuFabricant: www.idealspec.fr; Largeur: 0.354563 m; Longueur: 0.699915 m; WFU: 0; HWFU: 0; CWFU: 0; Version: 1; TypeDeCuvette: n/a; TypeDeWc: 0
POR_Matura_P2430_BIM_FR | P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC | POR_Matura_P2430_BIM_FR | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 1335252 | Appareils sanitaires | 2021_015 | Autre - Famille et type: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Famille: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Type: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; ID du type: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WCSEAT; Exporter au format IFC sous: IfcSanitaryTerminalType; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Cotes - Volume: 0.0293916 m3; Surface: 0.512996 m2; Phase de construction - Phase de création: Existant; Contraintes - Hôte: <non associé>; Élévation par rapport au niveau: 0 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 716556; Nom: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Elévation par défaut: 0.4 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: P243001; Fabricant: sav@idealstandard.com; URL: www.idealspec.fr; Description: Matura Cuv Susp Rallongee 70 Blanc; Titre OmniClass: Water Operated Water Closets; Numéro OmniClass: 23.45.05.21.11.11; Description de l'assemblage: Bath & Toilet Accessories; Code d'assemblage: C1030200; Sous-projet: Famille : Appareils sanitaires : POR_Matura_P2430_BIM_FR; Nom de la famille: POR_Matura_P2430_BIM_FR; Nom du type: P243001 - MATURA CUV SUSP RALLONGEE 70 BLANC; Commentaires du type: n/a; Finition: Blanc; Raccordement: Plomberie; Hauteur: 0.384201 m; Profondeur: 0.699915 m; Type: Type prédéfini d'IFC: WCPANS; Exporter le type au format IFC sous: IfcSanitaryType; Coût: 0.00; Accessoires: www.idealspec.fr; Caractéristiques: Cuvette suspendue rallongées Matura- P243001/ Porcher; CodeBarre: n/a; Composants: n/a; Conformité: NF; ConseilsDInstallation: www.idealspec.fr; ContactGarantieDesPièces: sav@idealstandard.com; Couleur: Blanc; CoûtDeRemplacement: 0; DateDeCréation: 2016-11-11; DébitL/Mn: 0; DétailGarantie: Constructeur; Dimensions: 700 x 355 x 385 mm; DuréeDeGarantieDesPièces: 2; DuréeDeGarantieDeTravail: n/a; DuréeDeVie: n/a; DuréeGarantie: ans; EffectuéPar: n/a; Espace: Interne; Forme: Complexe; GarantieDeTravail: n/a; Grade: n/a; LienUtile: sav@idealstandard.com; Marque: PORCHER; Matériel: Céramique; PerformanceAccessibilité: NF; PerformanceDeDurabilité: n/a; PiècesDétachées: sav@idealstandard.com; PoidsBrut: n/a; PoidsNet: 22 kg; Téléphone: 01.49.38.28.00; TypeDImmobilisation: Fixe; UnitéDeMesure: mm; UnitéDeTemps: an; UnitéMonétaire: n/a; ZoneDeMesure: n/a; IfcExportAs: IfcSanitaryType; IfcExportType: WCPANS; Auteur: www.idealstandardinternational.com; Bim-NomDuProjet: POR_Porcher_WcSystems_Matura_P243001; InformationsProduit: www.idealspec.fr; Révision: 1; Uniclass2015Code: Ss_40_15_90_97; Uniclass2015Title: WC systems; Uniclass2015Version: Products v1.1; UrlDuFabricant: www.idealspec.fr; Largeur: 0.354563 m; Longueur: 0.699915 m; WFU: 0; HWFU: 0; CWFU: 0; Version: 1; TypeDeCuvette: n/a; TypeDeWc: 0
Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC | Family | Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC | <NoLevel>
Pop-Up Waste - 65807000 | Type | Pop-Up Waste - 65807000 | <NoLevel>
Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC | Pop-Up Waste - 65807000 | Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 1335302 | Appareils sanitaires | 2021_015 | Autre - Famille et type: Pop-Up Waste - 65807000; Famille: Pop-Up Waste - 65807000; Type: Pop-Up Waste - 65807000; ID du type: Pop-Up Waste - 65807000; SerialNumber: 0; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Cotes - Volume: 0.0000674339 m3; Surface: 0.00710049 m2; Depth of Plug: 0.0140882 m; Phase de construction - Phase de création: Existant; Contraintes - Hôte: <non associé>; Élévation par rapport au niveau: 0 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 790001; Nom: Pop-Up Waste - 65807000; Elévation par défaut: 0.6 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: Pop-up Waste 65 807 000; Fabricant: Grohe AG; URL: www.grohe.com; Titre OmniClass: Mixing Faucets; Numéro OmniClass: 23.45.55.17; Description de l'assemblage: Bath & Toilet Accessories - Residential; Code d'assemblage: C1030220; Sous-projet: Famille : Appareils sanitaires : Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC; Nom de la famille: Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC; Nom du type: Pop-Up Waste - 65807000; Height: 0.148 m; Coût: 0.00; WFU: 0; HWFU: 4.5; CWFU: 4.5; AssetType: Fixed; CreatedBy: Connor Laing; CreatedOn: September 2014; ExpectedLife: 0; ModelNumber: Pop-up Waste 65 807 000; Ecojoy: no; ClassificationName: Uniclass2015; Length: 0.092 m; _BIMspec_GUID: 0; _created by: Connnor Laing; _current revision: 2; _distributed by: www.bimstore.co.uk; Version: 0; Industry Standards: N/A; ADA Compliant: yes; Warranty Infomation: N/A; Low Emitting Material: yes; Percentage of Recycled Content: 0; Width: 0.034 m; Flow Rate: approx 6 L/min; Operating Pressure: max 1MPa; Cold Water Radius: 0.005 m; Hot Water Radius: 0.005 m; Faucet Material: Grohe-Chrome; Mixing Leaver: yes; Barcode: 0; Name: Pop-up Waste 65 807 000; TagNumber: 0; _created date: September 2014; Contact Grohe: GROHE Limited, World Business Centre 2, Newall Road, London Heathrow Airport, Hounslow, Middlesex, TW6 2SF - Tel: +44 (0) 871 200 3414 - Fax: +44 (0) 871 200 3415 - EMail: info-uk@grohe.com; Hot Water Connection Diameter: 0.01 m; Cold Water Connection Diameter: 0.01 m; Flow Pressure: min 0.05MPa/recommended 0.1 - 0.6MPa; Temp - Hot Water Supply (Recommended): 60 deg C; Temp - Hot Water Supply: max 70 deg C; Manufacturers Address: World Business Centre 2, Newall Road, London Heathrow Airport, Hounslow, Middlesex , TW62SF; Manufacturers Email: info-uk@grohe.com; Manufacturers Telephone Number: 08712003414; Données d'identification - Masterformat Title: Residential Faucets, Supplies, and Trim; Masterformat Number: 22 41 39
3 x Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC | Instance | Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 793812 | Appareils sanitaires | Famille : Appareils sanitaires : Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC | Autre - Nom de la famille: Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC; AssetType: Fixed; CreatedBy: Connor Laing; CreatedOn: September 2014; ExpectedLife: 0; ModelNumber: Pop-up Waste 65 807 000; ClassificationName: Uniclass2015; Version: 0; Barcode: 0; Name: Pop-up Waste 65 807 000; TagNumber: 0; Données d'identification - Modèle: Pop-up Waste 65 807 000; Fabricant: Grohe AG; URL: www.grohe.com; Titre OmniClass: Mixing Faucets; Numéro OmniClass: 23.45.55.17; Description de l'assemblage: Bath & Toilet Accessories - Residential; Code d'assemblage: C1030220; Nom du type: Pop-Up Waste - 65807000; Note d'identification: 100_PLOMBERIE SANITAIRES; Coût: 0.00; Industry Standards: N/A; ADA Compliant: yes; Warranty Infomation: N/A; Ecojoy: no; Contact Grohe: GROHE Limited, World Business Centre 2, Newall Road, London Heathrow Airport, Hounslow, Middlesex, TW6 2SF - Tel: +44 (0) 871 200 3414 - Fax: +44 (0) 871 200 3415 - EMail: info-uk@grohe.com; Manufacturers Address: World Business Centre 2, Newall Road, London Heathrow Airport, Hounslow, Middlesex , TW62SF; Manufacturers Email: info-uk@grohe.com; Manufacturers Telephone Number: 08712003414; Contraintes - Elévation par défaut: 0.6 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Height: 0.148 m; Length: 0.092 m; Width: 0.034 m; Hot Water Connection Diameter: 0.01 m; Cold Water Connection Diameter: 0.01 m; Génie climatique - WFU: 0; HWFU: 4.5; CWFU: 4.5; Flow Rate: approx 6 L/min; Operating Pressure: max 1MPa; Flow Pressure: min 0.05MPa/recommended 0.1 - 0.6MPa; Temp - Hot Water Supply (Recommended): 60 deg C; Temp - Hot Water Supply: max 70 deg C; Général - _BIMspec_GUID: 0; _created by: Connnor Laing; _current revision: 2; _distributed by: www.bimstore.co.uk; _created date: September 2014; Propriétés Green Building - Low Emitting Material: yes; Percentage of Recycled Content: 0; Plomberie - Cold Water Radius: 0.005 m; Hot Water Radius: 0.005 m; Mixing Leaver: yes; Matériaux et finitions - Faucet Material: Grohe-Chrome
Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC | Pop-Up Waste - 65807000 | Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 1335351 | Appareils sanitaires | 2021_015 | Autre - Famille et type: Pop-Up Waste - 65807000; Famille: Pop-Up Waste - 65807000; Type: Pop-Up Waste - 65807000; ID du type: Pop-Up Waste - 65807000; SerialNumber: 0; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Cotes - Volume: 0.0000674339 m3; Surface: 0.00710049 m2; Depth of Plug: 0.0140882 m; Phase de construction - Phase de création: Existant; Contraintes - Hôte: <non associé>; Élévation par rapport au niveau: 0 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 790001; Nom: Pop-Up Waste - 65807000; Elévation par défaut: 0.6 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: Pop-up Waste 65 807 000; Fabricant: Grohe AG; URL: www.grohe.com; Titre OmniClass: Mixing Faucets; Numéro OmniClass: 23.45.55.17; Description de l'assemblage: Bath & Toilet Accessories - Residential; Code d'assemblage: C1030220; Sous-projet: Famille : Appareils sanitaires : Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC; Nom de la famille: Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC; Nom du type: Pop-Up Waste - 65807000; Height: 0.148 m; Coût: 0.00; WFU: 0; HWFU: 4.5; CWFU: 4.5; AssetType: Fixed; CreatedBy: Connor Laing; CreatedOn: September 2014; ExpectedLife: 0; ModelNumber: Pop-up Waste 65 807 000; Ecojoy: no; ClassificationName: Uniclass2015; Length: 0.092 m; _BIMspec_GUID: 0; _created by: Connnor Laing; _current revision: 2; _distributed by: www.bimstore.co.uk; Version: 0; Industry Standards: N/A; ADA Compliant: yes; Warranty Infomation: N/A; Low Emitting Material: yes; Percentage of Recycled Content: 0; Width: 0.034 m; Flow Rate: approx 6 L/min; Operating Pressure: max 1MPa; Cold Water Radius: 0.005 m; Hot Water Radius: 0.005 m; Faucet Material: Grohe-Chrome; Mixing Leaver: yes; Barcode: 0; Name: Pop-up Waste 65 807 000; TagNumber: 0; _created date: September 2014; Contact Grohe: GROHE Limited, World Business Centre 2, Newall Road, London Heathrow Airport, Hounslow, Middlesex, TW6 2SF - Tel: +44 (0) 871 200 3414 - Fax: +44 (0) 871 200 3415 - EMail: info-uk@grohe.com; Hot Water Connection Diameter: 0.01 m; Cold Water Connection Diameter: 0.01 m; Flow Pressure: min 0.05MPa/recommended 0.1 - 0.6MPa; Temp - Hot Water Supply (Recommended): 60 deg C; Temp - Hot Water Supply: max 70 deg C; Manufacturers Address: World Business Centre 2, Newall Road, London Heathrow Airport, Hounslow, Middlesex , TW62SF; Manufacturers Email: info-uk@grohe.com; Manufacturers Telephone Number: 08712003414; Données d'identification - Masterformat Title: Residential Faucets, Supplies, and Trim; Masterformat Number: 22 41 39
Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC | Pop-Up Waste - 65807000 | Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 1335352 | Appareils sanitaires | 2021_015 | Autre - Famille et type: Pop-Up Waste - 65807000; Famille: Pop-Up Waste - 65807000; Type: Pop-Up Waste - 65807000; ID du type: Pop-Up Waste - 65807000; SerialNumber: 0; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 2; Type de système: Eaux Usées; Cotes - Volume: 0.0000674339 m3; Surface: 0.00710049 m2; Depth of Plug: 0.0140882 m; Phase de construction - Phase de création: Existant; Contraintes - Hôte: <non associé>; Élévation par rapport au niveau: 0 m; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 790001; Nom: Pop-Up Waste - 65807000; Elévation par défaut: 0.6 m; Note d'identification: 100_PLOMBERIE SANITAIRES; Catégorie: Appareils sanitaires; Exporter le type au format IFC: 0; Modèle: Pop-up Waste 65 807 000; Fabricant: Grohe AG; URL: www.grohe.com; Titre OmniClass: Mixing Faucets; Numéro OmniClass: 23.45.55.17; Description de l'assemblage: Bath & Toilet Accessories - Residential; Code d'assemblage: C1030220; Sous-projet: Famille : Appareils sanitaires : Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC; Nom de la famille: Plumbing_Fixtures_Grohe_Pop_Up_Waste_65807000_14_METRIC; Nom du type: Pop-Up Waste - 65807000; Height: 0.148 m; Coût: 0.00; WFU: 0; HWFU: 4.5; CWFU: 4.5; AssetType: Fixed; CreatedBy: Connor Laing; CreatedOn: September 2014; ExpectedLife: 0; ModelNumber: Pop-up Waste 65 807 000; Ecojoy: no; ClassificationName: Uniclass2015; Length: 0.092 m; _BIMspec_GUID: 0; _created by: Connnor Laing; _current revision: 2; _distributed by: www.bimstore.co.uk; Version: 0; Industry Standards: N/A; ADA Compliant: yes; Warranty Infomation: N/A; Low Emitting Material: yes; Percentage of Recycled Content: 0; Width: 0.034 m; Flow Rate: approx 6 L/min; Operating Pressure: max 1MPa; Cold Water Radius: 0.005 m; Hot Water Radius: 0.005 m; Faucet Material: Grohe-Chrome; Mixing Leaver: yes; Barcode: 0; Name: Pop-up Waste 65 807 000; TagNumber: 0; _created date: September 2014; Contact Grohe: GROHE Limited, World Business Centre 2, Newall Road, London Heathrow Airport, Hounslow, Middlesex, TW6 2SF - Tel: +44 (0) 871 200 3414 - Fax: +44 (0) 871 200 3415 - EMail: info-uk@grohe.com; Hot Water Connection Diameter: 0.01 m; Cold Water Connection Diameter: 0.01 m; Flow Pressure: min 0.05MPa/recommended 0.1 - 0.6MPa; Temp - Hot Water Supply (Recommended): 60 deg C; Temp - Hot Water Supply: max 70 deg C; Manufacturers Address: World Business Centre 2, Newall Road, London Heathrow Airport, Hounslow, Middlesex , TW62SF; Manufacturers Email: info-uk@grohe.com; Manufacturers Telephone Number: 08712003414; Données d'identification - Masterformat Title: Residential Faucets, Supplies, and Trim; Masterformat Number: 22 41 39
Système de canalisation | Category | Système de canalisation | <NoLevel>
Système de canalisation | Family | Système de canalisation | <NoLevel>
Eau Froide Sanitaire | Type | Eau Froide Sanitaire | <NoLevel>
Eaux Usées | Type | Eaux Usées | <NoLevel>
Eau Chaude Sanitaire | Type | Eau Chaude Sanitaire | <NoLevel>
Systèmes de gaines | Category | Systèmes de gaines | <NoLevel>
Système de gaines | Family | Système de gaines | <NoLevel>
Reprise | Type | Reprise | <NoLevel>
Canalisation | Category | Canalisation | N0
Canalisation | Family | Canalisation | N0
5 x Standard | Type | Standard | N0
Canalisation | Standard | Canalisation | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1353506 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.0721006 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.281664 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 85; Contraintes - Arase inférieure à son extrémité aval: 0.089332 m; Arase supérieure à son extrémité amont: 0.110668 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0921006 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.0921006 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.107899 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.107899 m; Arase supérieure à son extrémité aval: 0.110668 m; Arase inférieure à son extrémité amont: 0.089332 m; Elévation de l'axe à son extrémité aval: 0.1 m; Elévation de l'axe à son extrémité amont: 0.1 m; Inclinaison: 0.00%; Elévation du milieu: 0.1 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.1 m; Élévation centrale de départ: 0.1 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.089332 m; Arase supérieure avec isolant à son extrémité aval: 0.110668 m; Arase inférieure avec isolant à son extrémité amont: 0.089332 m; Arase supérieure avec isolant à son extrémité amont: 0.110668 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 5.97709 m
Canalisation | Standard | Canalisation | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1353515 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.0721006 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0129009 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 85; Contraintes - Arase inférieure à son extrémité aval: 0.089332 m; Arase supérieure à son extrémité amont: 0.110668 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0921006 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.0921006 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.107899 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.107899 m; Arase supérieure à son extrémité aval: 0.110668 m; Arase inférieure à son extrémité amont: 0.089332 m; Elévation de l'axe à son extrémité aval: 0.1 m; Elévation de l'axe à son extrémité amont: 0.1 m; Inclinaison: 0.00%; Elévation du milieu: 0.1 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.1 m; Élévation centrale de départ: 0.1 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.089332 m; Arase supérieure avec isolant à son extrémité aval: 0.110668 m; Arase inférieure avec isolant à son extrémité amont: 0.089332 m; Arase supérieure avec isolant à son extrémité amont: 0.110668 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 0.273766 m
Canalisation | Standard | Canalisation | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1353674 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.672101 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0144712 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 85; Contraintes - Arase inférieure à son extrémité aval: 0.689332 m; Arase supérieure à son extrémité amont: 0.710668 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.692101 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.692101 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.707899 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.707899 m; Arase supérieure à son extrémité aval: 0.710668 m; Arase inférieure à son extrémité amont: 0.689332 m; Elévation de l'axe à son extrémité aval: 0.7 m; Elévation de l'axe à son extrémité amont: 0.7 m; Inclinaison: 0.00%; Elévation du milieu: 0.7 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.7 m; Élévation centrale de départ: 0.7 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.689332 m; Arase supérieure avec isolant à son extrémité aval: 0.710668 m; Arase inférieure avec isolant à son extrémité amont: 0.689332 m; Arase supérieure avec isolant à son extrémité amont: 0.710668 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 0.307089 m
Canalisation | Standard | Canalisation | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1353925 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.095909 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0194348 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 85; Contraintes - Arase inférieure à son extrémité aval: 0.115909 m; Arase supérieure à son extrémité amont: 0.528329 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.115909 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.528329 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.115909 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.528329 m; Arase supérieure à son extrémité aval: 0.115909 m; Arase inférieure à son extrémité amont: 0.528329 m; Elévation de l'axe à son extrémité aval: 0.115909 m; Elévation de l'axe à son extrémité amont: 0.528329 m; Elévation du milieu: 0.528329 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.115909 m; Élévation centrale de départ: 0.528329 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.115909 m; Arase supérieure avec isolant à son extrémité aval: 0.115909 m; Arase inférieure avec isolant à son extrémité amont: 0.528329 m; Arase supérieure avec isolant à son extrémité amont: 0.528329 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 0.41242 m
Canalisation | Standard | Canalisation | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1354444 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 1; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.554329 m; Diamètre: 0.015 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.00517241 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00289389; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 85; Contraintes - Arase inférieure à son extrémité aval: 0.574329 m; Arase supérieure à son extrémité amont: 0.684091 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.574329 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.684091 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.574329 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.684091 m; Arase supérieure à son extrémité aval: 0.574329 m; Arase inférieure à son extrémité amont: 0.684091 m; Elévation de l'axe à son extrémité aval: 0.574329 m; Elévation de l'axe à son extrémité amont: 0.684091 m; Elévation du milieu: 0.684091 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.574329 m; Élévation centrale de départ: 0.684091 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø15 mm; Arase inférieure avec isolant à son extrémité aval: 0.574329 m; Arase supérieure avec isolant à son extrémité aval: 0.574329 m; Arase inférieure avec isolant à son extrémité amont: 0.684091 m; Arase supérieure avec isolant à son extrémité amont: 0.684091 m; Cotes - Epaisseur de paroi: 0.0027686 m; Diamètre extérieur: 0.021336 m; Diamètre intérieur: 0.0157988 m; Taille: ø15 mm; Longueur: 0.109762 m
Canalisation | Standard | Canalisation | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1354622 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 3; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.660636 m; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.0144971 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00111801; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Contraintes - Arase inférieure à son extrémité aval: 0.680636 m; Arase supérieure à son extrémité amont: 0.796 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.680636 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.796 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.680636 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.796 m; Arase supérieure à son extrémité aval: 0.680636 m; Arase inférieure à son extrémité amont: 0.796 m; Elévation de l'axe à son extrémité aval: 0.680636 m; Elévation de l'axe à son extrémité amont: 0.796 m; Elévation du milieu: 0.680636 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.796 m; Élévation centrale de départ: 0.680636 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm; Arase inférieure avec isolant à son extrémité aval: 0.680636 m; Arase supérieure avec isolant à son extrémité aval: 0.680636 m; Arase inférieure avec isolant à son extrémité amont: 0.796 m; Arase supérieure avec isolant à son extrémité amont: 0.796 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Taille: ø40 mm; Longueur: 0.115364 m
Canalisation | Standard | Canalisation | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1354854 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau Froide Sanitaire 5; Type de système: Eau Froide Sanitaire; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): -0.0260479 m; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.072131 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit: 0.0 L/s; Pression dynamique: 0.0 Pa; Débit par appareil: 0; Débit supplémentaire: 0.0 L/s; Nombre de Reynolds: 0; Rugosité relative: 0.00111801; Etat du flux: 0; Facteur de frottement: 0; Vitesse: 0.0 m/s; Frottement: 0.00 Pa/m; Perte de pression: 0.0 Pa; Tronçon: 1; Contraintes - Arase inférieure à son extrémité aval: -0.00605686 m; Arase supérieure à son extrémité amont: 0.568059 m; Elévation du fond (fil d'eau) à son extrémité aval: -0.00604791 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.56795 m; Elévation du point haut intérieur du tube à son extrémité aval: -0.0059485 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.56805 m; Arase supérieure à son extrémité aval: -0.00593954 m; Arase inférieure à son extrémité amont: 0.567941 m; Elévation de l'axe à son extrémité aval: -0.0059982 m; Elévation de l'axe à son extrémité amont: 0.568 m; Inclinaison: 41136.52%; Elévation du milieu: 0.568 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: -0.0059982 m; Élévation centrale de départ: 0.568 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm; Arase inférieure avec isolant à son extrémité aval: -0.00605686 m; Arase supérieure avec isolant à son extrémité aval: -0.00593954 m; Arase inférieure avec isolant à son extrémité amont: 0.567941 m; Arase supérieure avec isolant à son extrémité amont: 0.568059 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Taille: ø40 mm; Longueur: 0.574 m
Canalisation | Standard | Canalisation | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1378682 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.0479495 m; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.150736 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit par appareil: 0; Rugosité relative: 0.00111801; Tronçon: 13; Contraintes - Arase inférieure à son extrémité aval: 0.0642665 m; Arase supérieure à son extrémité amont: 0.112526 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0679495 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.0679495 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.108843 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.108843 m; Arase supérieure à son extrémité aval: 0.112526 m; Arase inférieure à son extrémité amont: 0.0642665 m; Elévation de l'axe à son extrémité aval: 0.0883965 m; Elévation de l'axe à son extrémité amont: 0.0883965 m; Inclinaison: 0.00%; Elévation du milieu: 0.0883965 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.0883965 m; Élévation centrale de départ: 0.0883965 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm; Arase inférieure avec isolant à son extrémité aval: 0.0642665 m; Arase supérieure avec isolant à son extrémité aval: 0.112526 m; Arase inférieure avec isolant à son extrémité amont: 0.0642665 m; Arase supérieure avec isolant à son extrémité amont: 0.112526 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Taille: ø40 mm; Longueur: 1.19952 m
Canalisation | Standard | Canalisation | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1379136 | Canalisation | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: RIGIDSEGMENT; Exporter au format IFC sous: IfcPipeSegmentType; Revizto - Plumbing: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Génie climatique - Classification du système: Sanitaire; Nom du système: Eaux Usées 3; Type de système: Eaux Usées; Type de connexion: Générique; Segment de canalisation: Acier au carbone - Série 40; Elévation du fond (fil d'eau): 0.0681978 m; Diamètre: 0.04 m; Rugosité: 0.00004572 m; Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Surface: 0.154585 m2; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 03; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: PLOMBERIE/CVC; Type de Revit - Id: 142438; Nom: Standard; Catégorie: Canalisation; Exporter le type au format IFC: 0; Sous-projet: Canalisation; Nom de la famille: Canalisation; Nom du type: Standard; Génie climatique - Débit - Débit par appareil: 0; Rugosité relative: 0.00111801; Tronçon: 22; Contraintes - Arase inférieure à son extrémité aval: 0.0845148 m; Arase supérieure à son extrémité amont: 0.132775 m; Elévation du fond (fil d'eau) à son extrémité aval: 0.0881978 m; Elévation du fond (fil d'eau) à son extrémité amont: 0.0881978 m; Elévation du point haut intérieur du tube à son extrémité aval: 0.129092 m; Elévation du point haut intérieur du tube à son extrémité amont: 0.129092 m; Arase supérieure à son extrémité aval: 0.132775 m; Arase inférieure à son extrémité amont: 0.0845148 m; Elévation de l'axe à son extrémité aval: 0.108645 m; Elévation de l'axe à son extrémité amont: 0.108645 m; Inclinaison: 0.00%; Elévation du milieu: 0.108645 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 0.108645 m; Élévation centrale de départ: 0.108645 m; Niveau de référence: N0; Isolation - Epaisseur d'isolation: 0 m; Taille globale: ø40 mm; Arase inférieure avec isolant à son extrémité aval: 0.0845148 m; Arase supérieure avec isolant à son extrémité aval: 0.132775 m; Arase inférieure avec isolant à son extrémité amont: 0.0845148 m; Arase supérieure avec isolant à son extrémité amont: 0.132775 m; Cotes - Epaisseur de paroi: 0.003683 m; Diamètre extérieur: 0.04826 m; Diamètre intérieur: 0.040894 m; Taille: ø40 mm; Longueur: 1.23015 m
