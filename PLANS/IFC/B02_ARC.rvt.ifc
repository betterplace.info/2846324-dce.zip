Properties of the parts of a building model (IFC4), part 6 of 11

# IfcBuildingElementPart (663)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 394750 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 394913 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 394988 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 395057 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 395206 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 2.51587 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 395451 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 395602 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.03192 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 395701 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 395987 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 395990 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 395993 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 395996 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 395999 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 396002 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 396005 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 396008 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
610 | Type | 610 | N0_FINI
XXX_VIDE FENETRE | 610 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 400289 | Fenêtres | B02_ARC | Autre - Famille et type: 610; Famille: 610; Type: 610; ID du type: 610; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.49052 m2; Volume: 0.0244051 m3; Type de Revit - Id: 400400; Nom: 610; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 610; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Identifiant du type: 17; Elévation par défaut: 0 m; L_1: 0.61 m; L_2: 1.2567 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.953 m; Hôte: Niveau : N0_FINI; Données d'identification - Identifiant: 4
4 x XXX_VIDE FENETRE | Instance | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 400400 | Fenêtres | Famille : Fenêtres : XXX_VIDE FENETRE | Autre - Nom de la famille: XXX_VIDE FENETRE; Données d'identification - Nom du type: 610; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Identifiant du type: 17; Paramètres IFC - Exporter le type au format IFC: 0; Propriétés analytiques - Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Contraintes - Elévation par défaut: 0 m; Cotes - L_1: 0.61 m; L_2: 1.2567 m
XXX_VIDE FENETRE | 610 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 400414 | Fenêtres | B02_ARC | Autre - Famille et type: 610; Famille: 610; Type: 610; ID du type: 610; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.49052 m2; Volume: 0.0244051 m3; Type de Revit - Id: 400400; Nom: 610; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 610; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Identifiant du type: 17; Elévation par défaut: 0 m; L_1: 0.61 m; L_2: 1.2567 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.953 m; Hôte: Niveau : N0_FINI; Données d'identification - Identifiant: 5
XXX_VIDE FENETRE | 610 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 400417 | Fenêtres | B02_ARC | Autre - Famille et type: 610; Famille: 610; Type: 610; ID du type: 610; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.49052 m2; Volume: 0.0244051 m3; Type de Revit - Id: 400400; Nom: 610; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 610; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Identifiant du type: 17; Elévation par défaut: 0 m; L_1: 0.61 m; L_2: 1.2567 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.950342 m; Hôte: Niveau : N0_FINI; Données d'identification - Identifiant: 6
XXX_VIDE FENETRE | 610 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 400420 | Fenêtres | B02_ARC | Autre - Famille et type: 610; Famille: 610; Type: 610; ID du type: 610; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.49052 m2; Volume: 0.0244051 m3; Type de Revit - Id: 400400; Nom: 610; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 610; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Identifiant du type: 17; Elévation par défaut: 0 m; L_1: 0.61 m; L_2: 1.2567 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.9503 m; Hôte: Niveau : N0_FINI; Données d'identification - Identifiant: 7
Garde-corps | Category | Garde-corps | N0_FINI
Garde-corps | Family | Garde-corps | N0_FINI
43_PLINTHE 100mm | Type | 43_PLINTHE 100mm | N0_FINI
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 505470 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 28.1788 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 505471 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 505702 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 17.2091 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 505703 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 505842 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 19.1034 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 505843 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 506027 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 13.0115 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 506028 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 506285 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 2.98224 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 506286 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 506444 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 9.55571 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 506445 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 506760 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 9.28468 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 506761 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 507122 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 8.88367 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 507123 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 507163 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 3.55092 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 507164 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 507379 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 0.0800084 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 507380 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 507493 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 0.214654 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 507494 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 507582 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 5.17374 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 507583 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 508220 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 9.4302 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 508221 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 508648 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 0.17784 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 508649 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 508897 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 9.00688 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 508898 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 508959 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 2.11345 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 508960 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 509099 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 6.85104 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 509100 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 509142 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 1.84818 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 509143 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 509924 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 20.4853 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 509925 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 510087 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 20.4551 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 510088 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 510191 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 20.5937 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 510192 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 511183 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 1.31139 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 511184 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
