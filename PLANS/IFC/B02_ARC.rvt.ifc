Properties of the parts of a building model (IFC4), part 9 of 11

# IfcBuildingElementPart (663)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
Garde-corps | bordure t1 | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 496686 | Garde-corps | 2021_015_RAMPE | Autre - Famille et type: bordure t1; Famille: bordure t1; Type: bordure t1; ID du type: bordure t1; Paramètres IFC - Exporter au format IFC: 0; Exporter au format IFC sous: IfcKerbType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Cotes - Longueur: 7.17373 m; Type de Revit - Id: 484848; Nom: bordure t1; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: bordure t1; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 05; GEM_ROP_NOM DU LOT: VRD
Garde-corps | Instance | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 496687 |  | 2021_015_RAMPE | Données d'identification - Nom du type: Garde-corps
Garde-corps | bordure t1 | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 497032 | Garde-corps | 2021_015_RAMPE | Autre - Famille et type: bordure t1; Famille: bordure t1; Type: bordure t1; ID du type: bordure t1; Paramètres IFC - Exporter au format IFC: 0; Exporter au format IFC sous: IfcKerbType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Cotes - Longueur: 12.4711 m; Type de Revit - Id: 484848; Nom: bordure t1; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: bordure t1; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 05; GEM_ROP_NOM DU LOT: VRD
Garde-corps | Instance | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 497033 |  | 2021_015_RAMPE | Données d'identification - Nom du type: Garde-corps
bordure t1 2 | Type | bordure t1 2 | N0
Garde-corps | bordure t1 2 | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 487547 | Garde-corps | 2021_015_RAMPE | Autre - Famille et type: bordure t1 2; Famille: bordure t1 2; Type: bordure t1 2; ID du type: bordure t1 2; Paramètres IFC - Exporter au format IFC: 0; Exporter au format IFC sous: IfcKerbType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Cotes - Longueur: 18.2676 m; Type de Revit - Id: 487550; Nom: bordure t1 2; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: bordure t1 2; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 05; GEM_ROP_NOM DU LOT: VRD
Garde-corps | Instance | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 487548 |  | 2021_015_RAMPE | Données d'identification - Nom du type: Garde-corps
bordure t2 | Type | bordure t2 | N0
Garde-corps | bordure t2 | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 488649 | Garde-corps | 2021_015_RAMPE | Autre - Famille et type: bordure t2; Famille: bordure t2; Type: bordure t2; ID du type: bordure t2; Paramètres IFC - Exporter au format IFC: 0; Exporter au format IFC sous: IfcKerbType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: -0.12 m; Cotes - Longueur: 47.8653 m; Type de Revit - Id: 488721; Nom: bordure t2; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: bordure t2; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante
Garde-corps | Instance | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 488650 |  | 2021_015_RAMPE | Données d'identification - Nom du type: Garde-corps
Garde-corps | bordure t2 | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 492387 | Garde-corps | 2021_015_RAMPE | Autre - Famille et type: bordure t2; Famille: bordure t2; Type: bordure t2; ID du type: bordure t2; Paramètres IFC - Exporter au format IFC: 0; Exporter au format IFC sous: IfcKerbType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Cotes - Longueur: 12.1331 m; Type de Revit - Id: 488721; Nom: bordure t2; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: bordure t2; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante
Garde-corps | Instance | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 492388 |  | 2021_015_RAMPE | Données d'identification - Nom du type: Garde-corps
94_BANDE DE GUIDAGE 2 | Type | 94_BANDE DE GUIDAGE 2 | N0
Garde-corps | 94_BANDE DE GUIDAGE 2 | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 494343 | Garde-corps | 2021_015_RAMPE | Autre - Famille et type: 94_BANDE DE GUIDAGE 2; Famille: 94_BANDE DE GUIDAGE 2; Type: 94_BANDE DE GUIDAGE 2; ID du type: 94_BANDE DE GUIDAGE 2; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcBuildingElementProxy; IfcObjectType: Bande de guidage PMR; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: -0.15 m; Cotes - Longueur: 16.4779 m; Type de Revit - Id: 494712; Nom: 94_BANDE DE GUIDAGE 2; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 94_BANDE DE GUIDAGE 2; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 05; GEM_ROP_NOM DU LOT: VRD
Garde-corps | Instance | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 494344 |  | 2021_015_RAMPE | Données d'identification - Nom du type: Garde-corps
Garde-corps | 94_BANDE DE GUIDAGE 2 | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 497610 | Garde-corps | 2021_015_RAMPE | Autre - Famille et type: 94_BANDE DE GUIDAGE 2; Famille: 94_BANDE DE GUIDAGE 2; Type: 94_BANDE DE GUIDAGE 2; ID du type: 94_BANDE DE GUIDAGE 2; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcBuildingElementProxy; IfcObjectType: Bande de guidage PMR; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: -0.15 m; Cotes - Longueur: 13.6946 m; Type de Revit - Id: 494712; Nom: 94_BANDE DE GUIDAGE 2; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 94_BANDE DE GUIDAGE 2; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 05; GEM_ROP_NOM DU LOT: VRD
Garde-corps | Instance | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 497611 |  | 2021_015_RAMPE | Données d'identification - Nom du type: Garde-corps
Garde-corps | 94_BANDE DE GUIDAGE 2 | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 497896 | Garde-corps | 2021_015_RAMPE | Autre - Famille et type: 94_BANDE DE GUIDAGE 2; Famille: 94_BANDE DE GUIDAGE 2; Type: 94_BANDE DE GUIDAGE 2; ID du type: 94_BANDE DE GUIDAGE 2; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcBuildingElementProxy; IfcObjectType: Bande de guidage PMR; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: -0.15 m; Cotes - Longueur: 2.81713 m; Type de Revit - Id: 494712; Nom: 94_BANDE DE GUIDAGE 2; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 94_BANDE DE GUIDAGE 2; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 05; GEM_ROP_NOM DU LOT: VRD
Garde-corps | Instance | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 497897 |  | 2021_015_RAMPE | Données d'identification - Nom du type: Garde-corps
Fenêtres | Category | Fenêtres | N0
61_CADRE HABILLAGE MEUNUISERIE | Family | 61_CADRE HABILLAGE MEUNUISERIE | N0
0.65x1.01 | Type | 0.65x1.01 | N0
61_CADRE HABILLAGE MEUNUISERIE | 0.65x1.01 | 61_CADRE HABILLAGE MEUNUISERIE | N0 | CurrentWithCentral | NotOwned | foret-f | 528689 | Fenêtres | 2021_015 | Autre - Famille et type: 0.65x1.01; Famille: 0.65x1.01; Type: 0.65x1.01; ID du type: 0.65x1.01; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.7222 m2; Volume: 0.0100455 m3; Type de Revit - Id: 528671; Nom: 0.65x1.01; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : 61_CADRE HABILLAGE MEUNUISERIE; Nom de la famille: 61_CADRE HABILLAGE MEUNUISERIE; Nom du type: 0.65x1.01; Note d'identification: 61_FENETRE INTERIEURE; Largeur: 0.68 m; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Identifiant du type: 18; Hauteur: 1.06 m; Elévation par défaut: 0 m; Exporter le type au format IFC sous: IfcWindowType; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; Contraintes - Niveau: N0; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.024 m; Hôte: Sol : 34_RENFORMIS 2cm; Données d'identification - Identifiant: 8
61_CADRE HABILLAGE MEUNUISERIE | Instance | 61_CADRE HABILLAGE MEUNUISERIE | N0 | CurrentWithCentral | NotOwned | foret-f | 528671 | Fenêtres | Famille : Fenêtres : 61_CADRE HABILLAGE MEUNUISERIE | Autre - Nom de la famille: 61_CADRE HABILLAGE MEUNUISERIE; Données d'identification - Nom du type: 0.65x1.01; Note d'identification: 61_FENETRE INTERIEURE; Identifiant du type: 18; Cotes - Largeur: 0.68 m; Hauteur: 1.06 m; Paramètres IFC - Exporter le type au format IFC: 0; Exporter le type au format IFC sous: IfcWindowType; Propriétés analytiques - Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Contraintes - Elévation par défaut: 0 m
Equipement spécialisé | Category | Equipement spécialisé | N0
51_BARRE DE SEUIL INOXIDABLE | Family | 51_BARRE DE SEUIL INOXIDABLE | N0
51_BARRE DE SEUIL INOXIDABLE | Type | 51_BARRE DE SEUIL INOXIDABLE | N0
51_BARRE DE SEUIL INOXIDABLE | 51_BARRE DE SEUIL INOXIDABLE | 51_BARRE DE SEUIL INOXIDABLE | N0 | CurrentWithCentral | NotOwned | foret-f | 553718 | Equipement spécialisé | 2021_015 | Autre - Famille et type: 51_BARRE DE SEUIL INOXIDABLE; Famille: 51_BARRE DE SEUIL INOXIDABLE; Type: 51_BARRE DE SEUIL INOXIDABLE; ID du type: 51_BARRE DE SEUIL INOXIDABLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.170674 m2; Volume: 0.000793789 m3; Type de Revit - Id: 553672; Nom: 51_BARRE DE SEUIL INOXIDABLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 51_BARRE DE SEUIL INOXIDABLE; Nom de la famille: 51_BARRE DE SEUIL INOXIDABLE; Nom du type: 51_BARRE DE SEUIL INOXIDABLE; Largeur: 1.66 m; Elévation par défaut: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 2.18415e-17 m; Hôte: Sol : 34_RENFORMIS 2cm; Élévation par rapport au niveau: 2.18415e-17 m
2 x 51_BARRE DE SEUIL INOXIDABLE | Instance | 51_BARRE DE SEUIL INOXIDABLE | N0 | CurrentWithCentral | NotOwned | foret-f | 553672 | Equipement spécialisé | Famille : Equipement spécialisé : 51_BARRE DE SEUIL INOXIDABLE | Autre - Nom de la famille: 51_BARRE DE SEUIL INOXIDABLE; Données d'identification - Nom du type: 51_BARRE DE SEUIL INOXIDABLE; Cotes - Largeur: 1.66 m; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Elévation par défaut: 0 m
51_BARRE DE SEUIL INOXIDABLE | 51_BARRE DE SEUIL INOXIDABLE | 51_BARRE DE SEUIL INOXIDABLE | N0 | CurrentWithCentral | NotOwned | foret-f | 555086 | Equipement spécialisé | 2021_015 | Autre - Famille et type: 51_BARRE DE SEUIL INOXIDABLE; Famille: 51_BARRE DE SEUIL INOXIDABLE; Type: 51_BARRE DE SEUIL INOXIDABLE; ID du type: 51_BARRE DE SEUIL INOXIDABLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.170674 m2; Volume: 0.000793789 m3; Type de Revit - Id: 553672; Nom: 51_BARRE DE SEUIL INOXIDABLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 51_BARRE DE SEUIL INOXIDABLE; Nom de la famille: 51_BARRE DE SEUIL INOXIDABLE; Nom du type: 51_BARRE DE SEUIL INOXIDABLE; Largeur: 1.66 m; Elévation par défaut: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.008 m; Hôte: Sol : 34_RENFORMIS 2cm; Élévation par rapport au niveau: 0.008 m
72_MIROIR_GEN | Family | 72_MIROIR_GEN | N0
400x800 | Type | 400x800 | N0
72_MIROIR_GEN | 400x800 | 72_MIROIR_GEN | N0 | CurrentWithCentral | NotOwned | foret-f | 573824 | Equipement spécialisé | 2021_015 | Autre - Famille et type: 400x800; Famille: 400x800; Type: 400x800; ID du type: 400x800; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.3248 m2; Volume: 0.00128 m3; Type de Revit - Id: 573947; Nom: 400x800; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 72_MIROIR_GEN; Nom de la famille: 72_MIROIR_GEN; Nom du type: 400x800; Largeur: 0.4 m; Hauteur: 0.8 m; Elévation par défaut: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.3; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.9 m; Hôte: Niveau : N0; Élévation par rapport au niveau: 0.9 m
3 x 72_MIROIR_GEN | Instance | 72_MIROIR_GEN | N0 | CurrentWithCentral | NotOwned | foret-f | 573947 | Equipement spécialisé | Famille : Equipement spécialisé : 72_MIROIR_GEN | Autre - Nom de la famille: 72_MIROIR_GEN; Données d'identification - Nom du type: 400x800; Cotes - Largeur: 0.4 m; Hauteur: 0.8 m; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Elévation par défaut: 0 m
72_MIROIR_GEN | 400x800 | 72_MIROIR_GEN | N0 | CurrentWithCentral | NotOwned | foret-f | 574031 | Equipement spécialisé | 2021_015 | Autre - Famille et type: 400x800; Famille: 400x800; Type: 400x800; ID du type: 400x800; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.3248 m2; Volume: 0.00128 m3; Type de Revit - Id: 573947; Nom: 400x800; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 72_MIROIR_GEN; Nom de la famille: 72_MIROIR_GEN; Nom du type: 400x800; Largeur: 0.4 m; Hauteur: 0.8 m; Elévation par défaut: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.3; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.9 m; Hôte: Niveau : N0; Élévation par rapport au niveau: 0.9 m
72_MIROIR_GEN | 400x800 | 72_MIROIR_GEN | N0 | CurrentWithCentral | NotOwned | foret-f | 574043 | Equipement spécialisé | 2021_015 | Autre - Famille et type: 400x800; Famille: 400x800; Type: 400x800; ID du type: 400x800; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.3248 m2; Volume: 0.00128 m3; Type de Revit - Id: 573947; Nom: 400x800; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 72_MIROIR_GEN; Nom de la famille: 72_MIROIR_GEN; Nom du type: 400x800; Largeur: 0.4 m; Hauteur: 0.8 m; Elévation par défaut: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.3; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.9 m; Hôte: Niveau : N0; Élévation par rapport au niveau: 0.9 m
Plafonds | Category | Plafonds | N0
Plafond composé | Family | Plafond composé | N0
35_ISOLATION 260mm | Type | 35_ISOLATION 260mm | N0
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0 | CurrentWithCentral | NotOwned | foret-f | 556762 | Plafonds | 2021_015 | Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0; Décalage par rapport au niveau: 2.53 m; Cotes - Surface: 21.6 m2; Volume: 5.616 m3; Périmètre: 19.2 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.3; GEM_ROP_REPERE CCTP: TYPE E
Mobilier | Category | Mobilier | N0
72_PATERE_HEWI SERIE 477 | Family | 72_PATERE_HEWI SERIE 477 | N0
Colour - 92 Anthracite grey | Type | Colour - 92 Anthracite grey | N0
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 566305 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_95/70_1BA13_EIXX_31db; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
12 x 72_PATERE_HEWI SERIE 477 | Instance | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 566101 | Mobilier | Famille : Mobilier : 72_PATERE_HEWI SERIE 477 | Autre - Nom de la famille: 72_PATERE_HEWI SERIE 477; Données d'identification - Nom du type: Colour - 92 Anthracite grey; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Product data url: https://bimobject.com/hewi/product/477-90-045; Product url: https://catalog.hewi.com/en/-477.90.045; Technical description: https://catalog.hewi.com/en/-477.90.045; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Paramètres IFC - Exporter le type au format IFC: 0; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; IFC Classification: Sanitary Terminal; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Contraintes - Elévation par défaut: 1.2192 m; Général - Edition number: 1; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; Manufacturer country: Germany; Manufacturer name: HEWI; Product family: Sanitary; Product group: Hooks, Walking aid holders; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Weight Net (Kg): 0; Nominal width: 0 m; Matériaux et finitions - Material main: Polyamide; Material 1: HEWI - 92 Anthracite grey
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 566315 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_95/70_1BA13_EIXX_31db; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 566533 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_95/70_1BA13_EIXX_31db; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 566978 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_95/70_1BA13_EIXX_31db; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
6 x 72_PATERE_HEWI SERIE 477 | Instance | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 568995 | Mobilier | Famille : Mobilier : 72_PATERE_HEWI SERIE 477 | Autre - Nom de la famille: 72_PATERE_HEWI SERIE 477; Données d'identification - Nom du type: Colour - 92 Anthracite grey; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Product data url: https://bimobject.com/hewi/product/477-90-045; Product url: https://catalog.hewi.com/en/-477.90.045; Technical description: https://catalog.hewi.com/en/-477.90.045; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Paramètres IFC - Exporter le type au format IFC: 0; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; IFC Classification: Sanitary Terminal; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Contraintes - Elévation par défaut: 1.2192 m; Général - Edition number: 1; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; Manufacturer country: Germany; Manufacturer name: HEWI; Product family: Sanitary; Product group: Hooks, Walking aid holders; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Weight Net (Kg): 0; Nominal width: 0 m; Matériaux et finitions - Material main: Polyamide; Material 1: HEWI - 92 Anthracite grey
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 566980 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_95/70_1BA13_EIXX_31db; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 566981 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_95/70_1BA13_EIXX_31db; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 569923 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_95/70_1BA13_EIXX_31db; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 570126 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_95/70_1BA13_EIXX_31db; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 570133 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_95/70_1BA13_EIXX_31db; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 570218 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_95/70_1BA13_EIXX_31db; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 570362 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_95/70_1BA13_EIXX_31db; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 570369 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_95/70_1BA13_EIXX_31db; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
