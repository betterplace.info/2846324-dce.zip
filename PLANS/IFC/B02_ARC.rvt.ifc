Properties of the parts of a building model (IFC4), part 11 of 11

# IfcPlate (98)
Name | Installation ? | Elément, Type = Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Nom du type | Calque = Contrainte inférieure | Value = Authoring Tool Id | Type prédéfini d'IFC | Exporter au format IFC sous | Décalage inférieur (m) | Ligne de justification | Décalage supérieur (m) | Hauteur non contrainte (m) | Surface (m2) | Volume (m3) | Longueur (m) | Type de Revit, Id | Commentaires du type | Matériau structurel | Fonction | Largeur (m) | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Id | GEM_ROP_N°LOT | GEM_ROP_NOM DU LOT | GEM_ROP_LIGNE CCTP | GEM_ROP_REPERE CCTP | Type: Type prédéfini d'IFC
Mur de base | no | 43-PAR_BA13 | N0_FINI | 299698 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.25145 | 0.00314156 | 0.0788908 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE | Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 43-PAR_BA13 | N0_FINI | 316595 | BASE_PLATE | IfcPlateType | -0.01 | 0 | 0 | 2.75 | 1.39196 | 0.0173995 | 0.512418 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 316599 | BASE_PLATE | IfcPlateType | -0.01 | 0 | 0 | 2.045 | 1.03564 | 0.0129415 | 0.512521 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 316613 | BASE_PLATE | IfcPlateType | -0.01 | 0 | 0 | 2.05 | 0.394625 | 0.00493281 | 0.1925 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 316657 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.41 | 1.37284 | 0.0171593 | 0.582104 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 317195 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 1.22769 | 0.0153438 | 0.433865 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE | Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 43-PAR_BA13 | N0_FINI | 317231 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.439988 | 0.00512117 | 0.166281 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 317298 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.440087 | 0.00550054 | 0.166266 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 317658 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 1.24359 | 0.0155444 | 0.4397 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 317742 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.441424 | 0.0055173 | 0.166753 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 318747 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.428891 | 0.0053611 | 0.162209 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 318882 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.429441 | 0.00536797 | 0.162409 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 339625 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.0365 | 0.346205 | 0.00432756 | 0.1825 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 339751 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.05 | 0.39975 | 0.00499687 | 0.1825 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 339797 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.256081 | 0.00319866 | 0.103961 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 339823 | BASE_PLATE | IfcPlateType | -0.01 | 3 | 0 | 2.75 | 0.261968 | 0.00327192 | 0.106093 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 341096 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.62 | 0.360244 | 0.00449799 | 0.143595 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 341254 | BASE_PLATE | IfcPlateType | 2.086 | 2 | 0 | 0.524 | 0.77945 | 0.00974313 | 1.4875 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 342114 | BASE_PLATE | IfcPlateType | 2.0265 | 2 | 0 | 0.613553 | 0.912575 | 0.0114072 | 1.4875 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 342217 | BASE_PLATE | IfcPlateType | 2.0265 | 2 | 0 | 0.613553 | 0.912575 | 0.0114072 | 1.4875 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 360544 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.417384 | 0.00481508 | 0.241977 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base |  | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0 | 437131 | PARTITIONING | IfcWallType | 0 | 3 | -0.35 | 3.14205 | 28.1405 | 4.49861 | 11.7905 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT; Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base |  | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0 | 437200 | PARTITIONING | IfcWallType | 0 | 3 | -0.35 | 3.14205 | 17.6267 | 2.82016 | 6.27459 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT
Mur de base |  | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0 | 437230 | PARTITIONING | IfcWallType | 0 | 3 | -0.35 | 3.14205 | 15.0263 | 2.40211 | 6.40962 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT; Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base |  | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0 | 437248 | PARTITIONING | IfcWallType | 0 | 3 | -0.35 | 3.14205 | 2.87769 | 0.460333 | 1.18651 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT
Mur de base |  | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0 | 437296 | PARTITIONING | IfcWallType | 0 | 3 | -0.842 | 2.65005 | 1.69034 | 0.270454 | 1.73879 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT
Mur de base |  | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0 | 437325 | PARTITIONING | IfcWallType | 0 | 3 | -0.35 | 3.14205 | 19.8439 | 3.17486 | 6.23527 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT
Mur de base |  | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0 | 437461 | PARTITIONING | IfcWallType | 0 | 3 | -0.35 | 3.14205 | 6.3694 | 1.01865 | 2.10624 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT; Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base |  | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0 | 437557 | PARTITIONING | IfcWallType | 0 | 3 | -0.35 | 3.14205 | 27.7266 | 4.4338 | 9.86111 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT; Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base |  | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0 | 440504 | PARTITIONING | IfcWallType | 0 | 3 | -0.35 | 3.14205 | 1.83407 | 0.293161 | 0.755561 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT; Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base |  | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0 | 440765 | PARTITIONING | IfcWallType | 2.24 | 3 | -0.35 | 0.902053 | 1.33664 | 0.213737 | 1.48091 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT; Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base |  | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0 | 503548 | PARTITIONING | IfcWallType | 2.23 | 3 | -0.35 | 0.912053 | 6.2886 | 1.00618 | 6.895 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT
Mur de base | no | 43-PAR_BA13 | N0 | 440261 | BASE_PLATE | IfcPlateType | 0.01 | 3 | 0 | 2.03 | 0.155411 | 0.00194264 | 0.0703071 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base |  | 43-PAR_BA13 | N0 | 440358 | BASE_PLATE | IfcPlateType | 0 | 3 | 0 | 2.75 | 0.247662 | 0.00309476 | 0.0962794 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base |  | 43-PAR_BA13 | N0 | 442016 | BASE_PLATE | IfcPlateType | -6.58857e-14 | 3 | 0 | 2.95 | 0.48675 | 0.00608272 | 0.158705 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base |  | 43-PAR_BA13 | N0 | 442065 | BASE_PLATE | IfcPlateType | 0.2 | 3 | 0 | 2.75 | 0.104328 | 0.00130254 | 0.124142 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0 | 529071 |  |  | 2.06677 | 3 | 0 | 0.623226 | 0.503617 | 0.0062946 | 0.817451 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0 | 529562 |  |  | 2.04 | 3 | 0 | 0.91 | 0.89785 | 0.0112231 | 0.986717 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base |  | 43-PAR_BA13 | N0 | 529752 |  |  | 2.1025 | 3 | 0 | 0.6875 | 0.683203 | 0.00854004 | 0.99375 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base |  | 44_PROTECTION MURALE | N0 | 549093 |  |  | 0.11 | 3 | 0 | 1.9 | 5.11929 | 0.0102386 | 2.69237 | 548749 | Ext. Brique 22 | 44_PROTECTION MURALE | 1 | 0.002 | 1 | Existante | 3 | 04 | REVETEMENTS DE SOLS | 12.2.3 | - | BASE_PLATE
Mur de base |  | 44_PROTECTION MURALE | N0 | 549812 |  |  | 0.11 | 3 | 0 | 1.9 | 2.27585 | 0.00455169 | 1.19781 | 548749 | Ext. Brique 22 | 44_PROTECTION MURALE | 1 | 0.002 | 1 | Existante | 3 | 04 | REVETEMENTS DE SOLS | 12.2.3 | - | BASE_PLATE
Mur de base |  | 44_PROTECTION MURALE | N0 | 549894 |  |  | 0.11 | 3 | 0 | 1.9 | 5.11551 | 0.010231 | 2.69237 | 548749 | Ext. Brique 22 | 44_PROTECTION MURALE | 1 | 0.002 | 1 | Existante | 3 | 04 | REVETEMENTS DE SOLS | 12.2.3 | - | BASE_PLATE
Mur de base |  | 44_PROTECTION MURALE | N0 | 550034 |  |  | 0.11 | 3 | 0 | 1.9 | 0.166823 | 0.000333645 | 0.0888014 | 548749 | Ext. Brique 22 | 44_PROTECTION MURALE | 1 | 0.002 | 1 | Existante | 3 | 04 | REVETEMENTS DE SOLS | 12.2.3 | - | BASE_PLATE
Mur de base |  | 44_PROTECTION MURALE | N0 | 550162 |  |  | 0.11 | 3 | 0 | 1.9 | 0.168244 | 0.000336489 | 0.0895496 | 548749 | Ext. Brique 22 | 44_PROTECTION MURALE | 1 | 0.002 | 1 | Existante | 3 | 04 | REVETEMENTS DE SOLS | 12.2.3 | - | BASE_PLATE
Mur de base |  | 44_PROTECTION MURALE | N0 | 550351 |  |  | 0.11 | 3 | 0 | 1.9 | 0.170659 | 0.000341318 | 0.0888205 | 548749 | Ext. Brique 22 | 44_PROTECTION MURALE | 1 | 0.002 | 1 | Existante | 3 | 04 | REVETEMENTS DE SOLS | 12.2.3 | - | BASE_PLATE
Mur de base |  | 44_PROTECTION MURALE | N0 | 550497 |  |  | 0.11 | 3 | 0 | 1.9 | 5.11551 | 0.010231 | 2.69237 | 548749 | Ext. Brique 22 | 44_PROTECTION MURALE | 1 | 0.002 | 1 | Existante | 3 | 04 | REVETEMENTS DE SOLS | 12.2.3 | - | BASE_PLATE
Mur de base |  | 44_PROTECTION MURALE | N0 | 550786 |  |  | 0.11 | 3 | 0 | 1.9 | 2.27416 | 0.00454829 | 1.19892 | 548749 | Ext. Brique 22 | 44_PROTECTION MURALE | 1 | 0.002 | 1 | Existante | 3 | 04 | REVETEMENTS DE SOLS | 12.2.3 | - | BASE_PLATE
Mur de base |  | 44_PROTECTION MURALE | N0 | 550949 |  |  | 0.11 | 3 | 0 | 1.9 | 5.11957 | 0.0102391 | 2.69251 | 548749 | Ext. Brique 22 | 44_PROTECTION MURALE | 1 | 0.002 | 1 | Existante | 3 | 04 | REVETEMENTS DE SOLS | 12.2.3 | - | BASE_PLATE | Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base |  | 44_PROTECTION MURALE | N0 | 551027 |  |  | 0.11 | 3 | 0 | 1.9 | 0.204033 | 0.000407992 | 0.108367 | 548749 | Ext. Brique 22 | 44_PROTECTION MURALE | 1 | 0.002 | 1 | Existante | 3 | 04 | REVETEMENTS DE SOLS | 12.2.3 | - | BASE_PLATE
Mur de base |  | 44_PROTECTION MURALE | N0 | 551093 |  |  | 0.11 | 3 | 0 | 1.9 | 1.87031 | 0.00374061 | 0.983372 | 548749 | Ext. Brique 22 | 44_PROTECTION MURALE | 1 | 0.002 | 1 | Existante | 3 | 04 | REVETEMENTS DE SOLS | 12.2.3 | - | BASE_PLATE
Mur de base |  | 44_PROTECTION MURALE | N0 | 551099 |  |  | 0.11 | 3 | 0 | 1.9 | 5.11551 | 0.010231 | 2.69237 | 548749 | Ext. Brique 22 | 44_PROTECTION MURALE | 1 | 0.002 | 1 | Existante | 3 | 04 | REVETEMENTS DE SOLS | 12.2.3 | - | BASE_PLATE
Mur de base |  | 44_PROTECTION MURALE | N0 | 551105 |  |  | 0.11 | 3 | 0 | 1.9 | 4.08982 | 0.00817963 | 4.22619 | 548749 | Ext. Brique 22 | 44_PROTECTION MURALE | 1 | 0.002 | 1 | Existante | 3 | 04 | REVETEMENTS DE SOLS | 12.2.3 | - | BASE_PLATE
Mur de base |  | 44_PROTECTION MURALE | N0 | 551111 |  |  | 0.11 | 3 | 0 | 1.9 | 5.11551 | 0.010231 | 2.69237 | 548749 | Ext. Brique 22 | 44_PROTECTION MURALE | 1 | 0.002 | 1 | Existante | 3 | 04 | REVETEMENTS DE SOLS | 12.2.3 | - | BASE_PLATE
Mur de base |  | 44_PROTECTION MURALE | N0 | 551165 |  |  | 0.11 | 3 | 0 | 1.9 | 0.25466 | 0.000509318 | 0.135031 | 548749 | Ext. Brique 22 | 44_PROTECTION MURALE | 1 | 0.002 | 1 | Existante | 3 | 04 | REVETEMENTS DE SOLS | 12.2.3 | - | BASE_PLATE

# IfcRailing, Sanitary_Accessories_HEWI_HEWI-Hinged-support-rail-rotatable-801-5.0001
In: B02_ARC.rvt
Elément - Type: Instance; Nom: Sanitary_Accessories_HEWI_HEWI-Hinged-support-rail-rotatable-801-5.0001; Fichier source: B02_ARC.rvt; Calque: N0
Informations sur le partage du travail des éléments - État des mises à jour des modèles: CurrentWithCentral; État du retrait: NotOwned; Créateur: foret-f; Dernière modification par: foret-f
ElementId - Value: 584250
Autre - Catégorie: Mobilier; Nom de la famille: Sanitary_Accessories_HEWI_HEWI-Hinged-support-rail-rotatable-801-5.0001
Données d'identification - Sous-projet: Famille : Mobilier : Sanitary_Accessories_HEWI_HEWI-Hinged-support-rail-rotatable-801-5.0001; Nom du type: Default - please load Revit Family Type Catalog; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Product data url: https://www.bimobject.com/hewi/product/801-50-121; Product url: https://catalog.hewi.com/en/-801.50.121; Technical description: https://catalog.hewi.com/en/-801.50.121; Date Created: 2021/07/12; Date Updated: 2025/01/20; Version: 2; Installation instructions: https://catalog.hewi.com/en/-801.50.121
Revizto - Authoring Tool Id: 584250
Paramètres IFC - Exporter le type au format IFC: 0; BIMobject category: Accessories; IFC Classification: Sanitary Terminal; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; UNSPSC Code: 301815
Contraintes - Elévation par défaut: 1.2192 m
Général - Edition number: 1; Design country: Germany; Manufacturer country: Germany; Manufacturer name: HEWI; Product family: Accessibility; Product group: Hinged and stationary support rails; QR code: https://www.bimobject.com/hewi/product/801-50-121; Product SKU: 801-50-121; Product name: HEWI Hinged support rail, rotatable 801-50-121
Matériaux et finitions - Material main: Polyamide; Material 1: HEWI - 18 Mustard yellow; Material secondary: Steel; Material 2: HEWI - Black

# IfcRamp, Sol
In: B02_ARC.rvt
Elément - Type: 64_RAMPE PMR; Nom: Sol; Fichier source: B02_ARC.rvt; Calque: N0
Informations sur le partage du travail des éléments - État des mises à jour des modèles: CurrentWithCentral; État du retrait: NotOwned; Créateur: foret-f; Dernière modification par: foret-f
ElementId - Value: 481251
Autre - Catégorie: Sols; Famille et type: 64_RAMPE PMR; Famille: 64_RAMPE PMR; Type: 64_RAMPE PMR; ID du type: 64_RAMPE PMR
Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: HALF_TURN_RAMP; Exporter au format IFC sous: IfcRampType
Données d'identification - Sous-projet: 2021_015_RAMPE; A une association: no
Revizto - Authoring Tool Id: 481251; Architecture: yes; Structure: yes
Contraintes - Niveau: N0; Lié au volume: no; Limite de pièce: yes; Décalage par rapport au niveau: 0 m
Cotes - Périmètre: 49.9439 m; Surface: 41.4843 m2; Volume: 10.3711 m3; Epaisseur: 0.25 m
Type de Revit - Id: 480388; Nom: 64_RAMPE PMR; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 64_RAMPE PMR; Matériau structurel: Maçonnerie - Béton; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.25 m
Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3
Phase de construction - Phase de création: Existante
Structure - Structure: no
Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 05; GEM_ROP_NOM DU LOT: VRD
Modification de la forme de dalle - Condition de bord incurvé: 1
