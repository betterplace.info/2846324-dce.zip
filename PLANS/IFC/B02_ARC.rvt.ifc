Properties of the parts of a building model (IFC4), part 4 of 11

# IfcBuildingElementPart (663)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
PRT_SIMPLE_HUI_58x68x48 | PRT_BOIS_1V_930x2040x40 | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 359450 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: PRT_BOIS_1V_930x2040x40; Famille: PRT_BOIS_1V_930x2040x40; Type: PRT_BOIS_1V_930x2040x40; ID du type: PRT_BOIS_1V_930x2040x40; ID hôte: 23_CLS_95/70_1BA13_EIXX_31db; Hauteur sous linteau: 2.037 m; wwwww: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 2.18516 m2; Volume: 0.076475 m3; POIGNEE_DC_PR: 0.0485 m; HAUTEUR LIBRE: 2.0345 m; PASSAGE LIBRE: 0.864002 m; UP: 1; Type de Revit - Id: 552220; Nom: PRT_BOIS_1V_930x2040x40; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : PRT_SIMPLE_HUI_58x68x48; Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Nom du type: PRT_BOIS_1V_930x2040x40; Fonction: 0; Largeur: 0.93 m; 01RVZ_CLASSIFICATIONS: 51_PORTES INTERIEUR; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Identifiant du type: 38; Fermeture du mur: 0; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Hauteur: 2.047 m; Opération: SingleSwingLeft; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; CLASSEMENT AU FEU: Ame pleine; NOM DU MODELE: 1V EI30 - Portaphone - HB; URL 1 (FICHE TECHNIQUE): ..\01_FICHES_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\PORTES_SIMPLES\3-MBA-051_1V EI30 - Portaphone - HB.pdf; NOM DE L'ELEMENT: PORTES_SIMPLES; NOM DU BATIMENT: BIO; ISSUE DE SECOURS: no; TYPE DE PORTE: BOIS; HUISSERIE: BOIS; MATERIAU PANNEAU: Cadre bois exo. + ame pleine; IMPOSTE: no; PAUMELLES: Universelle Inox; URL 3 (PLANS 2D): ..\02_PLANS_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\LPA-L04-PLA-TN-E-5514_Repérage LPA_PRT.pdf; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.3.1; GEM_ROP_REPERE CCTP: F; Contraintes - Niveau: N0_FINI; Hauteur de l'appui: -0.01 m; Données d'identification - Identifiant: 22; Graphismes - Angle d'ouverture 3D: 0 deg; Angle d'ouverture 2D fixe: yes; Texte - TALON: 0.01
PRT_BOIS_1V_EI30_930x2040x40 | Type | PRT_BOIS_1V_EI30_930x2040x40 | N0_FINI
PRT_SIMPLE_HUI_58x68x48 | PRT_BOIS_1V_EI30_930x2040x40 | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 336903 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: PRT_BOIS_1V_EI30_930x2040x40; Famille: PRT_BOIS_1V_EI30_930x2040x40; Type: PRT_BOIS_1V_EI30_930x2040x40; ID du type: PRT_BOIS_1V_EI30_930x2040x40; ID hôte: 23_CLS_95/70_1BA13_EIXX_31db; Hauteur sous linteau: 2.037 m; wwwww: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 2.18516 m2; Volume: 0.076475 m3; POIGNEE_DC_PR: 0.0485 m; HAUTEUR LIBRE: 2.0345 m; PASSAGE LIBRE: 0.864002 m; UP: 1; Type de Revit - Id: 552218; Nom: PRT_BOIS_1V_EI30_930x2040x40; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : PRT_SIMPLE_HUI_58x68x48; Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Nom du type: PRT_BOIS_1V_EI30_930x2040x40; Fonction: 0; Largeur: 0.93 m; 01RVZ_CLASSIFICATIONS: 51_PORTES INTERIEUR; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Identifiant du type: 37; Fermeture du mur: 0; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Hauteur: 2.047 m; Opération: SingleSwingLeft; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; CLASSEMENT AU FEU: Ame pleine; NOM DU MODELE: 1V EI30 - Portaphone - HB; URL 1 (FICHE TECHNIQUE): ..\01_FICHES_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\PORTES_SIMPLES\3-MBA-051_1V EI30 - Portaphone - HB.pdf; NOM DE L'ELEMENT: PORTES_SIMPLES; NOM DU BATIMENT: BIO; ISSUE DE SECOURS: no; TYPE DE PORTE: BOIS; HUISSERIE: BOIS; MATERIAU PANNEAU: Cadre bois exo. + ame pleine; IMPOSTE: no; PAUMELLES: Universelle Inox; URL 3 (PLANS 2D): ..\02_PLANS_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\LPA-L04-PLA-TN-E-5514_Repérage LPA_PRT.pdf; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4.1; GEM_ROP_REPERE CCTP: F; GEM_SEC_DEGRE COUPE FEU: EI30; Contraintes - Niveau: N0_FINI; Hauteur de l'appui: -0.01 m; Données d'identification - Identifiant: 9; Graphismes - Angle d'ouverture 3D: 0 deg; Angle d'ouverture 2D fixe: yes; Texte - TALON: 0.01
PRT_SIMPLE_HUI_58x68x48 | Instance | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 552262 | Portes | Famille : Portes : PRT_SIMPLE_HUI_58x68x48 | Cotes - Epaisseur: 0.04 m; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Largeur: 0.93 m; Hauteur: 2.047 m; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; Autre - Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Données d'identification - Nom du type: PRT_BOIS_1V_EI30_930x2040x40; Paramètres IFC - Exporter le type au format IFC: 0; Opération: SingleSwingLeft; Propriétés analytiques - Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Construction - Fermeture du mur: 0; Fonction: 0; Données - PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; Protection contre les incendies - CLASSEMENT AU FEU: Ame pleine
Panneaux de murs-rideaux | Category | Panneaux de murs-rideaux | N0_FINI
Panneau système | Family | Panneau système | N0_FINI
Vitré | Type | Vitré | N0_FINI
Panneau système | Vitré | Panneau système | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 366563 | Panneaux de murs-rideaux | B02_ARC | Autre - Famille et type: Vitré; Famille: Vitré; Type: Vitré; ID du type: Vitré; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 2.72538 m2; Volume: 0.109015 m3; Largeur: 1.323 m; Hauteur: 2.06 m; Type de Revit - Id: 65935; Nom: Vitré; Catégorie: Panneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Panneaux de murs-rideaux : Panneau système; Nom de la famille: Panneau système; Nom du type: Vitré; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: GSP4R; Construction analytique: Simple vitrage Pilkington 1/8 po.; Transmission de la lumière visible: 0.9; Coefficient d'apport thermique solaire: 0.86; Résistance thermique (R): 0.1491 (m²·K)/W; Coefficient de transfert thermique (U): 6.7069 W/(m²·K); Décaler: 0 m; Matériau: Verre; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Panneau système | Instance | Panneau système | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367573 | Panneaux de murs-rideaux | Famille : Panneaux de murs-rideaux : Panneau système | Cotes - Epaisseur: 0.04 m; Autre - Nom de la famille: Panneau système; Données d'identification - Nom du type: Vitré; Paramètres IFC - Exporter le type au format IFC: 0; Propriétés analytiques - Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Contraintes - Décaler: 0 m; Matériaux et finitions - Matériau: Verre
Panneau système | Vitré | Panneau système | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367151 | Panneaux de murs-rideaux | B02_ARC | Autre - Famille et type: Vitré; Famille: Vitré; Type: Vitré; ID du type: Vitré; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 2.73568 m2; Volume: 0.109427 m3; Largeur: 1.328 m; Hauteur: 2.06 m; Type de Revit - Id: 65935; Nom: Vitré; Catégorie: Panneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Panneaux de murs-rideaux : Panneau système; Nom de la famille: Panneau système; Nom du type: Vitré; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: GSP4R; Construction analytique: Simple vitrage Pilkington 1/8 po.; Transmission de la lumière visible: 0.9; Coefficient d'apport thermique solaire: 0.86; Résistance thermique (R): 0.1491 (m²·K)/W; Coefficient de transfert thermique (U): 6.7069 W/(m²·K); Décaler: 0 m; Matériau: Verre; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Panneau système | Instance | Panneau système | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 356748 | Panneaux de murs-rideaux | Famille : Panneaux de murs-rideaux : Panneau système | Cotes - Epaisseur: 0.04 m; Autre - Nom de la famille: Panneau système; Données d'identification - Nom du type: Vitré; Paramètres IFC - Exporter le type au format IFC: 0; Propriétés analytiques - Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Contraintes - Décaler: 0 m; Matériaux et finitions - Matériau: Verre
Panneau système | Vitré | Panneau système | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367238 | Panneaux de murs-rideaux | B02_ARC | Autre - Famille et type: Vitré; Famille: Vitré; Type: Vitré; ID du type: Vitré; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 2.72332 m2; Volume: 0.108933 m3; Largeur: 1.322 m; Hauteur: 2.06 m; Type de Revit - Id: 65935; Nom: Vitré; Catégorie: Panneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Panneaux de murs-rideaux : Panneau système; Nom de la famille: Panneau système; Nom du type: Vitré; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: GSP4R; Construction analytique: Simple vitrage Pilkington 1/8 po.; Transmission de la lumière visible: 0.9; Coefficient d'apport thermique solaire: 0.86; Résistance thermique (R): 0.1491 (m²·K)/W; Coefficient de transfert thermique (U): 6.7069 W/(m²·K); Décaler: 0 m; Matériau: Verre; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Panneau système | Instance | Panneau système | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 356749 | Panneaux de murs-rideaux | Famille : Panneaux de murs-rideaux : Panneau système | Cotes - Epaisseur: 0.04 m; Autre - Nom de la famille: Panneau système; Données d'identification - Nom du type: Vitré; Paramètres IFC - Exporter le type au format IFC: 0; Propriétés analytiques - Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Contraintes - Décaler: 0 m; Matériaux et finitions - Matériau: Verre
Panneau système | Vitré | Panneau système | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 368044 | Panneaux de murs-rideaux | B02_ARC | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: Vitré; Famille: Vitré; Type: Vitré; ID du type: Vitré; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 1.24364 m2; Volume: 0.0497457 m3; Largeur: 0.603629 m; Hauteur: 2.06028 m; Type de Revit - Id: 65935; Nom: Vitré; Catégorie: Panneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Panneaux de murs-rideaux : Panneau système; Nom de la famille: Panneau système; Nom du type: Vitré; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: GSP4R; Construction analytique: Simple vitrage Pilkington 1/8 po.; Transmission de la lumière visible: 0.9; Coefficient d'apport thermique solaire: 0.86; Résistance thermique (R): 0.1491 (m²·K)/W; Coefficient de transfert thermique (U): 6.7069 W/(m²·K); Décaler: 0 m; Matériau: Verre; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Panneau système | Instance | Panneau système | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 441912 | Panneaux de murs-rideaux | Famille : Panneaux de murs-rideaux : Panneau système | Cotes - Epaisseur: 0.04 m; Autre - Nom de la famille: Panneau système; Données d'identification - Nom du type: Vitré; Paramètres IFC - Exporter le type au format IFC: 0; Propriétés analytiques - Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Contraintes - Décaler: 0 m; Matériaux et finitions - Matériau: Verre
Meneaux de murs-rideaux | Category | Meneaux de murs-rideaux | N0_FINI
Meneau rectangulaire | Family | Meneau rectangulaire | N0_FINI
AWS60_60x70 | Type | AWS60_60x70 | N0_FINI
Meneau rectangulaire | AWS60_60x70 | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367254 | Meneaux de murs-rideaux | B02_ARC | Autre - Famille et type: AWS60_60x70; Famille: AWS60_60x70; Type: AWS60_60x70; ID du type: AWS60_60x70; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.1862 m2; Volume: 0.00588 m3; Longueur: 1.4 m; Type de Revit - Id: 347216; Nom: AWS60_60x70; Catégorie: Meneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Meneaux de murs-rideaux : Meneau rectangulaire; Nom de la famille: Meneau rectangulaire; Nom du type: AWS60_60x70; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.06 m; Décaler: 0 m; Matériau: 60_ALU 7016; Angle: 0 deg; Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Largeur du côté 2: 0.035 m; Largeur du côté 1: 0.035 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Meneau rectangulaire | Instance | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 347310 | Meneaux de murs-rideaux | Famille : Meneaux de murs-rideaux : Meneau rectangulaire | Autre - Nom de la famille: Meneau rectangulaire; Données d'identification - Nom du type: AWS60_60x70; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Décaler: 0 m; Angle: 0 deg; Matériaux et finitions - Matériau: 60_ALU 7016; Construction - Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Epaisseur: 0.06 m; Cotes - Largeur du côté 2: 0.035 m; Largeur du côté 1: 0.035 m
Meneau rectangulaire | AWS60_60x70 | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367255 | Meneaux de murs-rideaux | B02_ARC | Autre - Famille et type: AWS60_60x70; Famille: AWS60_60x70; Type: AWS60_60x70; ID du type: AWS60_60x70; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.18685 m2; Volume: 0.005901 m3; Longueur: 1.405 m; Type de Revit - Id: 347216; Nom: AWS60_60x70; Catégorie: Meneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Meneaux de murs-rideaux : Meneau rectangulaire; Nom de la famille: Meneau rectangulaire; Nom du type: AWS60_60x70; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.06 m; Décaler: 0 m; Matériau: 60_ALU 7016; Angle: 0 deg; Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Largeur du côté 2: 0.035 m; Largeur du côté 1: 0.035 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Meneau rectangulaire | Instance | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367281 | Meneaux de murs-rideaux | Famille : Meneaux de murs-rideaux : Meneau rectangulaire | Autre - Nom de la famille: Meneau rectangulaire; Données d'identification - Nom du type: AWS60_60x70; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Décaler: 0 m; Angle: 0 deg; Matériaux et finitions - Matériau: 60_ALU 7016; Construction - Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Epaisseur: 0.06 m; Cotes - Largeur du côté 2: 0.035 m; Largeur du côté 1: 0.035 m
Meneau rectangulaire | AWS60_60x70 | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367256 | Meneaux de murs-rideaux | B02_ARC | Autre - Famille et type: AWS60_60x70; Famille: AWS60_60x70; Type: AWS60_60x70; ID du type: AWS60_60x70; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.1862 m2; Volume: 0.00588 m3; Longueur: 1.4 m; Type de Revit - Id: 347216; Nom: AWS60_60x70; Catégorie: Meneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Meneaux de murs-rideaux : Meneau rectangulaire; Nom de la famille: Meneau rectangulaire; Nom du type: AWS60_60x70; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.06 m; Décaler: 0 m; Matériau: 60_ALU 7016; Angle: 0 deg; Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Largeur du côté 2: 0.035 m; Largeur du côté 1: 0.035 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Meneau rectangulaire | Instance | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367276 | Meneaux de murs-rideaux | Famille : Meneaux de murs-rideaux : Meneau rectangulaire | Autre - Nom de la famille: Meneau rectangulaire; Données d'identification - Nom du type: AWS60_60x70; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Décaler: 0 m; Angle: 0 deg; Matériaux et finitions - Matériau: 60_ALU 7016; Construction - Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Epaisseur: 0.06 m; Cotes - Largeur du côté 2: 0.035 m; Largeur du côté 1: 0.035 m
Meneau rectangulaire | AWS60_60x70 | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 368693 | Meneaux de murs-rideaux | B02_ARC | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: AWS60_60x70; Famille: AWS60_60x70; Type: AWS60_60x70; ID du type: AWS60_60x70; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.0826717 m2; Volume: 0.00253524 m3; Longueur: 0.603629 m; Type de Revit - Id: 347216; Nom: AWS60_60x70; Catégorie: Meneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Meneaux de murs-rideaux : Meneau rectangulaire; Nom de la famille: Meneau rectangulaire; Nom du type: AWS60_60x70; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.06 m; Décaler: 0 m; Matériau: 60_ALU 7016; Angle: 0 deg; Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Largeur du côté 2: 0.035 m; Largeur du côté 1: 0.035 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Meneau rectangulaire | Instance | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 441910 | Meneaux de murs-rideaux | Famille : Meneaux de murs-rideaux : Meneau rectangulaire | Autre - Nom de la famille: Meneau rectangulaire; Données d'identification - Nom du type: AWS60_60x70; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Décaler: 0 m; Angle: 0 deg; Matériaux et finitions - Matériau: 60_ALU 7016; Construction - Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Epaisseur: 0.06 m; Cotes - Largeur du côté 2: 0.035 m; Largeur du côté 1: 0.035 m
AWS60_60x38 | Type | AWS60_60x38 | N0_FINI
Meneau rectangulaire | AWS60_60x38 | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367264 | Meneaux de murs-rideaux | B02_ARC | Autre - Famille et type: AWS60_60x38; Famille: AWS60_60x38; Type: AWS60_60x38; ID du type: AWS60_60x38; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.20416 m2; Volume: 0.0046968 m3; Longueur: 2.06 m; Type de Revit - Id: 347194; Nom: AWS60_60x38; Catégorie: Meneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Meneaux de murs-rideaux : Meneau rectangulaire; Nom de la famille: Meneau rectangulaire; Nom du type: AWS60_60x38; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.06 m; Décaler: 0 m; Matériau: 60_ALU 7016; Angle: 0 deg; Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Largeur du côté 2: 0.019 m; Largeur du côté 1: 0.019 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Meneau rectangulaire | Instance | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 356571 | Meneaux de murs-rideaux | Famille : Meneaux de murs-rideaux : Meneau rectangulaire | Autre - Nom de la famille: Meneau rectangulaire; Données d'identification - Nom du type: AWS60_60x38; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Décaler: 0 m; Angle: 0 deg; Matériaux et finitions - Matériau: 60_ALU 7016; Construction - Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Epaisseur: 0.06 m; Cotes - Largeur du côté 2: 0.019 m; Largeur du côté 1: 0.019 m
Meneau rectangulaire | AWS60_60x38 | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367268 | Meneaux de murs-rideaux | B02_ARC | Autre - Famille et type: AWS60_60x38; Famille: AWS60_60x38; Type: AWS60_60x38; ID du type: AWS60_60x38; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.20416 m2; Volume: 0.0046968 m3; Longueur: 2.06 m; Type de Revit - Id: 347194; Nom: AWS60_60x38; Catégorie: Meneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Meneaux de murs-rideaux : Meneau rectangulaire; Nom de la famille: Meneau rectangulaire; Nom du type: AWS60_60x38; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.06 m; Décaler: 0 m; Matériau: 60_ALU 7016; Angle: 0 deg; Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Largeur du côté 2: 0.019 m; Largeur du côté 1: 0.019 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Meneau rectangulaire | Instance | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 356570 | Meneaux de murs-rideaux | Famille : Meneaux de murs-rideaux : Meneau rectangulaire | Autre - Nom de la famille: Meneau rectangulaire; Données d'identification - Nom du type: AWS60_60x38; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Décaler: 0 m; Angle: 0 deg; Matériaux et finitions - Matériau: 60_ALU 7016; Construction - Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Epaisseur: 0.06 m; Cotes - Largeur du côté 2: 0.019 m; Largeur du côté 1: 0.019 m
Meneau rectangulaire | AWS60_60x38 | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 368699 | Meneaux de murs-rideaux | B02_ARC | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: AWS60_60x38; Famille: AWS60_60x38; Type: AWS60_60x38; ID du type: AWS60_60x38; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.220847 m2; Volume: 0.00508503 m3; Longueur: 2.23028 m; Type de Revit - Id: 347194; Nom: AWS60_60x38; Catégorie: Meneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Meneaux de murs-rideaux : Meneau rectangulaire; Nom de la famille: Meneau rectangulaire; Nom du type: AWS60_60x38; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.06 m; Décaler: 0 m; Matériau: 60_ALU 7016; Angle: 0 deg; Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Largeur du côté 2: 0.019 m; Largeur du côté 1: 0.019 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Meneau rectangulaire | Instance | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 368963 | Meneaux de murs-rideaux | Famille : Meneaux de murs-rideaux : Meneau rectangulaire | Autre - Nom de la famille: Meneau rectangulaire; Données d'identification - Nom du type: AWS60_60x38; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Décaler: 0 m; Angle: 0 deg; Matériaux et finitions - Matériau: 60_ALU 7016; Construction - Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Epaisseur: 0.06 m; Cotes - Largeur du côté 2: 0.019 m; Largeur du côté 1: 0.019 m
Meneau rectangulaire | AWS60_60x38 | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 368704 | Meneaux de murs-rideaux | B02_ARC | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: AWS60_60x38; Famille: AWS60_60x38; Type: AWS60_60x38; ID du type: AWS60_60x38; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.220847 m2; Volume: 0.00508503 m3; Longueur: 2.23028 m; Type de Revit - Id: 347194; Nom: AWS60_60x38; Catégorie: Meneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Meneaux de murs-rideaux : Meneau rectangulaire; Nom de la famille: Meneau rectangulaire; Nom du type: AWS60_60x38; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.06 m; Décaler: 0 m; Matériau: 60_ALU 7016; Angle: 0 deg; Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Largeur du côté 2: 0.019 m; Largeur du côté 1: 0.019 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Meneau rectangulaire | Instance | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 368964 | Meneaux de murs-rideaux | Famille : Meneaux de murs-rideaux : Meneau rectangulaire | Autre - Nom de la famille: Meneau rectangulaire; Données d'identification - Nom du type: AWS60_60x38; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Décaler: 0 m; Angle: 0 deg; Matériaux et finitions - Matériau: 60_ALU 7016; Construction - Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Epaisseur: 0.06 m; Cotes - Largeur du côté 2: 0.019 m; Largeur du côté 1: 0.019 m
AWS60_60x78 | Type | AWS60_60x78 | N0_FINI
Meneau rectangulaire | AWS60_60x78 | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367274 | Meneaux de murs-rideaux | B02_ARC | Autre - Famille et type: AWS60_60x78; Famille: AWS60_60x78; Type: AWS60_60x78; ID du type: AWS60_60x78; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.28896 m2; Volume: 0.0096408 m3; Longueur: 2.06 m; Type de Revit - Id: 347183; Nom: AWS60_60x78; Catégorie: Meneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Meneaux de murs-rideaux : Meneau rectangulaire; Nom de la famille: Meneau rectangulaire; Nom du type: AWS60_60x78; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.06 m; Décaler: 0 m; Matériau: 60_ALU 7016; Angle: 0 deg; Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Largeur du côté 2: 0.039 m; Largeur du côté 1: 0.039 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
2 x Meneau rectangulaire | Instance | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 356563 | Meneaux de murs-rideaux | Famille : Meneaux de murs-rideaux : Meneau rectangulaire | Autre - Nom de la famille: Meneau rectangulaire; Données d'identification - Nom du type: AWS60_60x78; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Décaler: 0 m; Angle: 0 deg; Matériaux et finitions - Matériau: 60_ALU 7016; Construction - Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Epaisseur: 0.06 m; Cotes - Largeur du côté 2: 0.039 m; Largeur du côté 1: 0.039 m
Meneau rectangulaire | AWS60_60x78 | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367280 | Meneaux de murs-rideaux | B02_ARC | Autre - Famille et type: AWS60_60x78; Famille: AWS60_60x78; Type: AWS60_60x78; ID du type: AWS60_60x78; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.28896 m2; Volume: 0.0096408 m3; Longueur: 2.06 m; Type de Revit - Id: 347183; Nom: AWS60_60x78; Catégorie: Meneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Meneaux de murs-rideaux : Meneau rectangulaire; Nom de la famille: Meneau rectangulaire; Nom du type: AWS60_60x78; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.06 m; Décaler: 0 m; Matériau: 60_ALU 7016; Angle: 0 deg; Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Largeur du côté 2: 0.039 m; Largeur du côté 1: 0.039 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
AWS60_60x100 | Type | AWS60_60x100 | N0_FINI
Meneau rectangulaire | AWS60_60x100 | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367286 | Meneaux de murs-rideaux | B02_ARC | Autre - Famille et type: AWS60_60x100; Famille: AWS60_60x100; Type: AWS60_60x100; ID du type: AWS60_60x100; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.23 m2; Volume: 0.0084 m3; Longueur: 1.4 m; Type de Revit - Id: 347237; Nom: AWS60_60x100; Catégorie: Meneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Meneaux de murs-rideaux : Meneau rectangulaire; Nom de la famille: Meneau rectangulaire; Nom du type: AWS60_60x100; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.06 m; Décaler: 0 m; Matériau: 60_ALU 7016; Angle: 0 deg; Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Largeur du côté 2: 0.05 m; Largeur du côté 1: 0.05 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Meneau rectangulaire | Instance | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367290 | Meneaux de murs-rideaux | Famille : Meneaux de murs-rideaux : Meneau rectangulaire | Autre - Nom de la famille: Meneau rectangulaire; Données d'identification - Nom du type: AWS60_60x100; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Décaler: 0 m; Angle: 0 deg; Matériaux et finitions - Matériau: 60_ALU 7016; Construction - Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Epaisseur: 0.06 m; Cotes - Largeur du côté 2: 0.05 m; Largeur du côté 1: 0.05 m
Meneau rectangulaire | AWS60_60x100 | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367287 | Meneaux de murs-rideaux | B02_ARC | Autre - Famille et type: AWS60_60x100; Famille: AWS60_60x100; Type: AWS60_60x100; ID du type: AWS60_60x100; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.23 m2; Volume: 0.0084 m3; Longueur: 1.4 m; Type de Revit - Id: 347237; Nom: AWS60_60x100; Catégorie: Meneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Meneaux de murs-rideaux : Meneau rectangulaire; Nom de la famille: Meneau rectangulaire; Nom du type: AWS60_60x100; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.06 m; Décaler: 0 m; Matériau: 60_ALU 7016; Angle: 0 deg; Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Largeur du côté 2: 0.05 m; Largeur du côté 1: 0.05 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Meneau rectangulaire | Instance | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 347268 | Meneaux de murs-rideaux | Famille : Meneaux de murs-rideaux : Meneau rectangulaire | Autre - Nom de la famille: Meneau rectangulaire; Données d'identification - Nom du type: AWS60_60x100; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Décaler: 0 m; Angle: 0 deg; Matériaux et finitions - Matériau: 60_ALU 7016; Construction - Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Epaisseur: 0.06 m; Cotes - Largeur du côté 2: 0.05 m; Largeur du côté 1: 0.05 m
Meneau rectangulaire | AWS60_60x100 | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367288 | Meneaux de murs-rideaux | B02_ARC | Autre - Famille et type: AWS60_60x100; Famille: AWS60_60x100; Type: AWS60_60x100; ID du type: AWS60_60x100; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.2308 m2; Volume: 0.00843 m3; Longueur: 1.405 m; Type de Revit - Id: 347237; Nom: AWS60_60x100; Catégorie: Meneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Meneaux de murs-rideaux : Meneau rectangulaire; Nom de la famille: Meneau rectangulaire; Nom du type: AWS60_60x100; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.06 m; Décaler: 0 m; Matériau: 60_ALU 7016; Angle: 0 deg; Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Largeur du côté 2: 0.05 m; Largeur du côté 1: 0.05 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Meneau rectangulaire | Instance | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 367291 | Meneaux de murs-rideaux | Famille : Meneaux de murs-rideaux : Meneau rectangulaire | Autre - Nom de la famille: Meneau rectangulaire; Données d'identification - Nom du type: AWS60_60x100; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Décaler: 0 m; Angle: 0 deg; Matériaux et finitions - Matériau: 60_ALU 7016; Construction - Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Epaisseur: 0.06 m; Cotes - Largeur du côté 2: 0.05 m; Largeur du côté 1: 0.05 m
Meneau rectangulaire | AWS60_60x100 | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 368696 | Meneaux de murs-rideaux | B02_ARC | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: AWS60_60x100; Famille: AWS60_60x100; Type: AWS60_60x100; ID du type: AWS60_60x100; ID hôte: Simple panneau; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.102581 m2; Volume: 0.00362177 m3; Longueur: 0.603629 m; Type de Revit - Id: 347237; Nom: AWS60_60x100; Catégorie: Meneaux de murs-rideaux; Exporter le type au format IFC: 0; Sous-projet: Famille : Meneaux de murs-rideaux : Meneau rectangulaire; Nom de la famille: Meneau rectangulaire; Nom du type: AWS60_60x100; Note d'identification: 22_MUR RIDEAU; Epaisseur: 0.06 m; Décaler: 0 m; Matériau: 60_ALU 7016; Angle: 0 deg; Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Largeur du côté 2: 0.05 m; Largeur du côté 1: 0.05 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI
Meneau rectangulaire | Instance | Meneau rectangulaire | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 441911 | Meneaux de murs-rideaux | Famille : Meneaux de murs-rideaux : Meneau rectangulaire | Autre - Nom de la famille: Meneau rectangulaire; Données d'identification - Nom du type: AWS60_60x100; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Décaler: 0 m; Angle: 0 deg; Matériaux et finitions - Matériau: 60_ALU 7016; Construction - Position: Perpendiculaire à la face; Profil: Profil des meneaux du système: rectangulaire; Meneau d'angle: no; Epaisseur: 0.06 m; Cotes - Largeur du côté 2: 0.05 m; Largeur du côté 1: 0.05 m
Modèles génériques | Category | Modèles génériques | N0_FINI
12_CORNIERE HABILLAGE | Family | 12_CORNIERE HABILLAGE | N0_FINI
12_CORNIERE HABILLAGE | Type | 12_CORNIERE HABILLAGE | N0_FINI
12_CORNIERE HABILLAGE | 12_CORNIERE HABILLAGE | 12_CORNIERE HABILLAGE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 370888 | Modèles génériques | B02_ARC | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 12_CORNIERE HABILLAGE; Famille: 12_CORNIERE HABILLAGE; Type: 12_CORNIERE HABILLAGE; ID du type: 12_CORNIERE HABILLAGE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Cotes - Surface: 3.07297 m2; Volume: 0.00609881 m3; Type de Revit - Id: 370872; Nom: 12_CORNIERE HABILLAGE; Catégorie: Modèles génériques; Exporter le type au format IFC: 0; Sous-projet: Famille : Modèles génériques : 12_CORNIERE HABILLAGE; Nom de la famille: 12_CORNIERE HABILLAGE; Nom du type: 12_CORNIERE HABILLAGE; Note d'identification: 50_PORTE EXTERIEUR; Elévation par défaut: 0 m; L1: 6.8842 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: -0.01 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: -0.01 m
12_CORNIERE HABILLAGE | Instance | 12_CORNIERE HABILLAGE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 370872 | Modèles génériques | Famille : Modèles génériques : 12_CORNIERE HABILLAGE | Autre - Nom de la famille: 12_CORNIERE HABILLAGE; Données d'identification - Nom du type: 12_CORNIERE HABILLAGE; Note d'identification: 50_PORTE EXTERIEUR; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Elévation par défaut: 0 m; Cotes - L1: 6.8842 m
Fenêtres | Category | Fenêtres | N0_FINI
XXX_VIDE FENETRE | Family | XXX_VIDE FENETRE | N0_FINI
550 | Type | 550 | N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 377565 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
39 x XXX_VIDE FENETRE | Instance | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 377501 | Fenêtres | Famille : Fenêtres : XXX_VIDE FENETRE | Autre - Nom de la famille: XXX_VIDE FENETRE; Données d'identification - Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Paramètres IFC - Exporter le type au format IFC: 0; Propriétés analytiques - Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Contraintes - Elévation par défaut: 0 m; Cotes - L_1: 0.55 m; L_2: 1.2017 m
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 380716 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 380817 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 380950 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 381147 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 381288 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 381439 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 381544 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 381661 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 381892 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 381985 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 382118 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 382255 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 382386 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 382501 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
