Properties of the parts of a building model (IFC4), part 7 of 11

# IfcBuildingElementPart (663)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 511338 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 2.11049 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 511339 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 511835 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 4.09129 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 511836 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 512181 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 2.985 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 512182 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 512325 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 4.31964 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 512326 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 512699 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 0.321577 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 512700 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 512912 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 0.274622 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 512913 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 513131 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 0.344729 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 513132 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 513302 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 3.99278 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 513303 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE 100mm | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 513391 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE 100mm; Famille: 43_PLINTHE 100mm; Type: 43_PLINTHE 100mm; ID du type: 43_PLINTHE 100mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 4.31233 m; Type de Revit - Id: 505473; Nom: 43_PLINTHE 100mm; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE 100mm; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.4; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 513392 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
43_PLINTHE REMONTE DE SOL | Type | 43_PLINTHE REMONTE DE SOL | N0_FINI
Garde-corps | 43_PLINTHE REMONTE DE SOL | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 522137 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE REMONTE DE SOL; Famille: 43_PLINTHE REMONTE DE SOL; Type: 43_PLINTHE REMONTE DE SOL; ID du type: 43_PLINTHE REMONTE DE SOL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SKIRTINGBOARD; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 8.64902 m; Type de Revit - Id: 522134; Nom: 43_PLINTHE REMONTE DE SOL; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE REMONTE DE SOL; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.5; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 522138 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE REMONTE DE SOL | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 522877 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE REMONTE DE SOL; Famille: 43_PLINTHE REMONTE DE SOL; Type: 43_PLINTHE REMONTE DE SOL; ID du type: 43_PLINTHE REMONTE DE SOL; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 6.76943 m; Type de Revit - Id: 522134; Nom: 43_PLINTHE REMONTE DE SOL; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE REMONTE DE SOL; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.5; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 522878 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Garde-corps | 43_PLINTHE REMONTE DE SOL | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 523016 | Garde-corps | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PLINTHE REMONTE DE SOL; Famille: 43_PLINTHE REMONTE DE SOL; Type: 43_PLINTHE REMONTE DE SOL; ID du type: 43_PLINTHE REMONTE DE SOL; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Niveau de base: N0_FINI; Cotes - Longueur: 6.78981 m; Type de Revit - Id: 522134; Nom: 43_PLINTHE REMONTE DE SOL; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: 43_PLINTHE REMONTE DE SOL; Note d'identification: 44_SOL FINITION; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS - PEINTURES; GEM_ROP_LIGNE CCTP: 12.2.5; GEM_ROP_REPERE CCTP: -
Garde-corps | Instance | Garde-corps | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 523017 |  | 2021_015 | Données d'identification - Nom du type: Garde-corps
Meubles de rangement | Category | Meubles de rangement | N0_FINI
72_SOUS EVIER | Family | 72_SOUS EVIER | N0_FINI
Type A | Type | Type A | N0_FINI
72_SOUS EVIER | Type A | 72_SOUS EVIER | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 519601 | Meubles de rangement | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: Type A; Famille: Type A; Type: Type A; ID du type: Type A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 9.08913 m2; Volume: 0.108925 m3; Type de Revit - Id: 516873; Nom: Type A; Catégorie: Meubles de rangement; Exporter le type au format IFC: 0; Sous-projet: Famille : Meubles de rangement : 72_SOUS EVIER; Nom de la famille: 72_SOUS EVIER; Nom du type: Type A; Note d'identification: 72_MOBILIER GENERIQUE; Largeur: 2.6 m; Hauteur: 0.9 m; Elévation par défaut: 0 m; Titre OmniClass: Casework; Numéro OmniClass: 23.40.35.00; Profondeur: 0.6 m; EP 1: 0.0125 m; PORTE: yes; RAL 5010: RAL 5010; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.6; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 6.76792e-17 m; Hôte: Sol : 44_SOL TYPE A; Élévation par rapport au niveau: 6.76792e-17 m
72_SOUS EVIER | Instance | 72_SOUS EVIER | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 516873 | Meubles de rangement | Famille : Meubles de rangement : 72_SOUS EVIER | Autre - Nom de la famille: 72_SOUS EVIER; Données d'identification - Nom du type: Type A; Note d'identification: 72_MOBILIER GENERIQUE; Titre OmniClass: Casework; Numéro OmniClass: 23.40.35.00; Cotes - Largeur: 2.6 m; Hauteur: 0.9 m; Profondeur: 0.6 m; EP 1: 0.0125 m; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Elévation par défaut: 0 m; Visibilité - PORTE: yes; Matériaux et finitions - RAL 5010: RAL 5010
Equipement spécialisé | Category | Equipement spécialisé | N0_FINI
1010_PROTECTION D'ANGLE | Family | 1010_PROTECTION D'ANGLE | N0_FINI
1010_PROTECTION D'ANGLE | Type | 1010_PROTECTION D'ANGLE | N0_FINI
1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 534431 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE; Famille: 1010_PROTECTION D'ANGLE; Type: 1010_PROTECTION D'ANGLE; ID du type: 1010_PROTECTION D'ANGLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.125231 m2; Volume: 0.00114849 m3; ANGLE: 10 deg; Type de Revit - Id: 534363; Nom: 1010_PROTECTION D'ANGLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE; Nom de la famille: 1010_PROTECTION D'ANGLE; Nom du type: 1010_PROTECTION D'ANGLE; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
12 x 1010_PROTECTION D'ANGLE | Instance | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 534363 | Equipement spécialisé | Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE | Autre - Nom de la famille: 1010_PROTECTION D'ANGLE; 45°: yes; Données d'identification - Nom du type: 1010_PROTECTION D'ANGLE; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Cotes - Hauteur: 1.2 m; Paramètres IFC - Exporter le type au format IFC: 0; IfcObjectType: Protection d’angle; Type: Type prédéfini d'IFC: USERDEFINED; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Contraintes - Elévation par défaut: 0.1 m
1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 536477 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE; Famille: 1010_PROTECTION D'ANGLE; Type: 1010_PROTECTION D'ANGLE; ID du type: 1010_PROTECTION D'ANGLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.125231 m2; Volume: 0.00114849 m3; ANGLE: 10 deg; Type de Revit - Id: 534363; Nom: 1010_PROTECTION D'ANGLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE; Nom de la famille: 1010_PROTECTION D'ANGLE; Nom du type: 1010_PROTECTION D'ANGLE; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
2 x 1010_PROTECTION D'ANGLE | Instance | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 540501 | Equipement spécialisé | Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE | Autre - Nom de la famille: 1010_PROTECTION D'ANGLE; 45°: yes; Données d'identification - Nom du type: 1010_PROTECTION D'ANGLE; Cotes - Hauteur: 1.2 m; Paramètres IFC - Exporter le type au format IFC: 0; IfcObjectType: Protection d’angle; Type: Type prédéfini d'IFC: USERDEFINED; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Contraintes - Elévation par défaut: 0.1 m
1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 536512 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE; Famille: 1010_PROTECTION D'ANGLE; Type: 1010_PROTECTION D'ANGLE; ID du type: 1010_PROTECTION D'ANGLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.125231 m2; Volume: 0.00114849 m3; ANGLE: 10 deg; Type de Revit - Id: 534363; Nom: 1010_PROTECTION D'ANGLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE; Nom de la famille: 1010_PROTECTION D'ANGLE; Nom du type: 1010_PROTECTION D'ANGLE; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 536530 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE; Famille: 1010_PROTECTION D'ANGLE; Type: 1010_PROTECTION D'ANGLE; ID du type: 1010_PROTECTION D'ANGLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.125231 m2; Volume: 0.00114849 m3; ANGLE: 10 deg; Type de Revit - Id: 534363; Nom: 1010_PROTECTION D'ANGLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE; Nom de la famille: 1010_PROTECTION D'ANGLE; Nom du type: 1010_PROTECTION D'ANGLE; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 536548 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE; Famille: 1010_PROTECTION D'ANGLE; Type: 1010_PROTECTION D'ANGLE; ID du type: 1010_PROTECTION D'ANGLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.125231 m2; Volume: 0.00114849 m3; ANGLE: 10 deg; Type de Revit - Id: 534363; Nom: 1010_PROTECTION D'ANGLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE; Nom de la famille: 1010_PROTECTION D'ANGLE; Nom du type: 1010_PROTECTION D'ANGLE; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 536598 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE; Famille: 1010_PROTECTION D'ANGLE; Type: 1010_PROTECTION D'ANGLE; ID du type: 1010_PROTECTION D'ANGLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.125231 m2; Volume: 0.00114849 m3; ANGLE: 10 deg; Type de Revit - Id: 534363; Nom: 1010_PROTECTION D'ANGLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE; Nom de la famille: 1010_PROTECTION D'ANGLE; Nom du type: 1010_PROTECTION D'ANGLE; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 536673 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE; Famille: 1010_PROTECTION D'ANGLE; Type: 1010_PROTECTION D'ANGLE; ID du type: 1010_PROTECTION D'ANGLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.125231 m2; Volume: 0.00114849 m3; ANGLE: 10 deg; Type de Revit - Id: 534363; Nom: 1010_PROTECTION D'ANGLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE; Nom de la famille: 1010_PROTECTION D'ANGLE; Nom du type: 1010_PROTECTION D'ANGLE; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 536689 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE; Famille: 1010_PROTECTION D'ANGLE; Type: 1010_PROTECTION D'ANGLE; ID du type: 1010_PROTECTION D'ANGLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.125231 m2; Volume: 0.00114849 m3; ANGLE: 10 deg; Type de Revit - Id: 534363; Nom: 1010_PROTECTION D'ANGLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE; Nom de la famille: 1010_PROTECTION D'ANGLE; Nom du type: 1010_PROTECTION D'ANGLE; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 536728 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE; Famille: 1010_PROTECTION D'ANGLE; Type: 1010_PROTECTION D'ANGLE; ID du type: 1010_PROTECTION D'ANGLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.125231 m2; Volume: 0.00114849 m3; ANGLE: 10 deg; Type de Revit - Id: 534363; Nom: 1010_PROTECTION D'ANGLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE; Nom de la famille: 1010_PROTECTION D'ANGLE; Nom du type: 1010_PROTECTION D'ANGLE; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 536980 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE; Famille: 1010_PROTECTION D'ANGLE; Type: 1010_PROTECTION D'ANGLE; ID du type: 1010_PROTECTION D'ANGLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.125231 m2; Volume: 0.00114849 m3; ANGLE: 10 deg; Type de Revit - Id: 534363; Nom: 1010_PROTECTION D'ANGLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE; Nom de la famille: 1010_PROTECTION D'ANGLE; Nom du type: 1010_PROTECTION D'ANGLE; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 537626 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE; Famille: 1010_PROTECTION D'ANGLE; Type: 1010_PROTECTION D'ANGLE; ID du type: 1010_PROTECTION D'ANGLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.125231 m2; Volume: 0.00114849 m3; ANGLE: 10 deg; Type de Revit - Id: 534363; Nom: 1010_PROTECTION D'ANGLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE; Nom de la famille: 1010_PROTECTION D'ANGLE; Nom du type: 1010_PROTECTION D'ANGLE; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 539464 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE; Famille: 1010_PROTECTION D'ANGLE; Type: 1010_PROTECTION D'ANGLE; ID du type: 1010_PROTECTION D'ANGLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.125231 m2; Volume: 0.00114849 m3; ANGLE: 10 deg; Type de Revit - Id: 534363; Nom: 1010_PROTECTION D'ANGLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE; Nom de la famille: 1010_PROTECTION D'ANGLE; Nom du type: 1010_PROTECTION D'ANGLE; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 539625 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE; Famille: 1010_PROTECTION D'ANGLE; Type: 1010_PROTECTION D'ANGLE; ID du type: 1010_PROTECTION D'ANGLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.125231 m2; Volume: 0.00114849 m3; ANGLE: 10 deg; Type de Revit - Id: 534363; Nom: 1010_PROTECTION D'ANGLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE; Nom de la famille: 1010_PROTECTION D'ANGLE; Nom du type: 1010_PROTECTION D'ANGLE; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | 1010_PROTECTION D'ANGLE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 539651 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE; Famille: 1010_PROTECTION D'ANGLE; Type: 1010_PROTECTION D'ANGLE; ID du type: 1010_PROTECTION D'ANGLE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.125231 m2; Volume: 0.00114849 m3; ANGLE: 10 deg; Type de Revit - Id: 534363; Nom: 1010_PROTECTION D'ANGLE; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE; Nom de la famille: 1010_PROTECTION D'ANGLE; Nom du type: 1010_PROTECTION D'ANGLE; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
1010_PROTECTION D'ANGLE 120° | Family | 1010_PROTECTION D'ANGLE 120° | N0_FINI
1010_PROTECTION D'ANGLE 120° | Type | 1010_PROTECTION D'ANGLE 120° | N0_FINI
1010_PROTECTION D'ANGLE 120° | 1010_PROTECTION D'ANGLE 120° | 1010_PROTECTION D'ANGLE 120° | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 541365 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE 120°; Famille: 1010_PROTECTION D'ANGLE 120°; Type: 1010_PROTECTION D'ANGLE 120°; ID du type: 1010_PROTECTION D'ANGLE 120°; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.122045 m2; Volume: 0.00111689 m3; ANGLE: 10 deg; Type de Revit - Id: 541349; Nom: 1010_PROTECTION D'ANGLE 120°; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE 120°; Nom de la famille: 1010_PROTECTION D'ANGLE 120°; Nom du type: 1010_PROTECTION D'ANGLE 120°; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
1010_PROTECTION D'ANGLE 120° | Instance | 1010_PROTECTION D'ANGLE 120° | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 541349 | Equipement spécialisé | Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE 120° | Autre - Nom de la famille: 1010_PROTECTION D'ANGLE 120°; 45°: yes; Données d'identification - Nom du type: 1010_PROTECTION D'ANGLE 120°; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Cotes - Hauteur: 1.2 m; Paramètres IFC - Exporter le type au format IFC: 0; IfcObjectType: Protection d’angle; Type: Type prédéfini d'IFC: USERDEFINED; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Contraintes - Elévation par défaut: 0.1 m
1010_PROTECTION D'ANGLE 151° | Family | 1010_PROTECTION D'ANGLE 151° | N0_FINI
1010_PROTECTION D'ANGLE 151° | Type | 1010_PROTECTION D'ANGLE 151° | N0_FINI
1010_PROTECTION D'ANGLE 151° | 1010_PROTECTION D'ANGLE 151° | 1010_PROTECTION D'ANGLE 151° | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 542862 | Equipement spécialisé | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 1010_PROTECTION D'ANGLE 151°; Famille: 1010_PROTECTION D'ANGLE 151°; Type: 1010_PROTECTION D'ANGLE 151°; ID du type: 1010_PROTECTION D'ANGLE 151°; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.11869 m2; Volume: 0.00108362 m3; ANGLE: 10 deg; Type de Revit - Id: 542846; Nom: 1010_PROTECTION D'ANGLE 151°; Catégorie: Equipement spécialisé; Exporter le type au format IFC: 0; Sous-projet: Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE 151°; Nom de la famille: 1010_PROTECTION D'ANGLE 151°; Nom du type: 1010_PROTECTION D'ANGLE 151°; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Hauteur: 1.2 m; Elévation par défaut: 0.1 m; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Type: Type prédéfini d'IFC: USERDEFINED; IfcObjectType: Protection d’angle; 45°: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 0.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 0.1 m
1010_PROTECTION D'ANGLE 151° | Instance | 1010_PROTECTION D'ANGLE 151° | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 542846 | Equipement spécialisé | Famille : Equipement spécialisé : 1010_PROTECTION D'ANGLE 151° | Autre - Nom de la famille: 1010_PROTECTION D'ANGLE 151°; 45°: yes; Données d'identification - Nom du type: 1010_PROTECTION D'ANGLE 151°; Note d'identification: 1010_PROTECTIONS DES OUVRAGES; Cotes - Hauteur: 1.2 m; Paramètres IFC - Exporter le type au format IFC: 0; IfcObjectType: Protection d’angle; Type: Type prédéfini d'IFC: USERDEFINED; Exporter le type au format IFC sous: IfcBuildingElementProxyType; Contraintes - Elévation par défaut: 0.1 m
Niveaux | Category | Niveaux | <NoLevel>
Niveau | Family | Niveau | <NoLevel>
Ligne du Niveau | Type | Ligne du Niveau | <NoLevel>
Quadrillage du mur-rideau | Category | Quadrillage du mur-rideau | <NoLevel>
Sols | Category | Sols | N0
Sol | Family | Sol | N0
34_RENFORMIS 2cm | Type | 34_RENFORMIS 2cm | N0
Sol | 34_RENFORMIS 2cm | Sol | N0 | CurrentWithCentral | NotOwned | foret-f | 313628 | Sols | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 34_RENFORMIS 2cm; Famille: 34_RENFORMIS 2cm; Type: 34_RENFORMIS 2cm; ID du type: 34_RENFORMIS 2cm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0; Décalage par rapport au niveau: 0 m; Cotes - Surface: 484.346 m2; Volume: 9.68734 m3; Périmètre: 212.21 m; Epaisseur: 0.02 m; Elévation au niveau du noyau inférieur: -0.02 m; Elévation au niveau du noyau supérieur: 1.37406e-13 m; Elévation en haut: 1.37408e-13 m; Elévation à la base: -0.02 m; Type de Revit - Id: 313630; Nom: 34_RENFORMIS 2cm; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 34_RENFORMIS 2cm; Note d'identification: 44_SOL FINITION; Matériau structurel: 23_RENFORMIS 2cm; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.1.1; GEM_ROP_REPERE CCTP: TYPE A; Données d'identification - A une association: no
44_SOL TYPE A | Type | 44_SOL TYPE A | N0
14_ISOLATION TT | Type | 14_ISOLATION TT | N0
Sol | 14_ISOLATION TT | Sol | N0 | CurrentWithCentral | NotOwned | foret-f | 429399 | Sols | B02_ARC | Autre - Famille et type: 14_ISOLATION TT; Famille: 14_ISOLATION TT; Type: 14_ISOLATION TT; ID du type: 14_ISOLATION TT; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0; Décalage par rapport au niveau: 3.81101 m; Cotes - Surface: 4.67979 m2; Volume: 0.467979 m3; Périmètre: 19.1932 m; Epaisseur: 0.1 m; Elévation au niveau du noyau inférieur: 3.71101 m; Elévation au niveau du noyau supérieur: 3.81101 m; Elévation en haut: 3.81101 m; Elévation à la base: 3.71101 m; Type de Revit - Id: 425735; Nom: 14_ISOLATION TT; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 14_ISOLATION TT; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Matériau structurel: 34_ISOLANT TT; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Données d'identification - A une association: no
64_RAMPE PMR | Type | 64_RAMPE PMR | N0
92_VOIE CIRCULATION | Type | 92_VOIE CIRCULATION | N0
Sol | 92_VOIE CIRCULATION | Sol | N0 | CurrentWithCentral | NotOwned | foret-f | 486750 | Sols | 2021_015_RAMPE | Autre - Famille et type: 92_VOIE CIRCULATION; Famille: 92_VOIE CIRCULATION; Type: 92_VOIE CIRCULATION; ID du type: 92_VOIE CIRCULATION; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0; Décalage par rapport au niveau: -0.595 m; Cotes - Surface: 222.475 m2; Volume: 88.9901 m3; Périmètre: 81.8809 m; Epaisseur: 0.4 m; Type de Revit - Id: 489835; Nom: 92_VOIE CIRCULATION; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 92_VOIE CIRCULATION; Matériau structurel: BANDE STERIL; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.4 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Données d'identification - A une association: no; Modification de la forme de dalle - Condition de bord incurvé: 1
95_BANDE STERIL | Type | 95_BANDE STERIL | N0
Sol | 95_BANDE STERIL | Sol | N0 | CurrentWithCentral | NotOwned | foret-f | 488157 | Sols | 2021_015_RAMPE | Autre - Famille et type: 95_BANDE STERIL; Famille: 95_BANDE STERIL; Type: 95_BANDE STERIL; ID du type: 95_BANDE STERIL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: EXTERNAL; Exporter au format IFC sous: IfcExternalSpatialElement; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0; Décalage par rapport au niveau: -0.28 m; Cotes - Surface: 21.5845 m2; Volume: 8.63379 m3; Périmètre: 73.9491 m; Epaisseur: 0.4 m; Type de Revit - Id: 486752; Nom: 95_BANDE STERIL; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 95_BANDE STERIL; Matériau structurel: BANDE STERIL; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.4 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 05; GEM_ROP_NOM DU LOT: VRD; Données d'identification - A une association: no; Modification de la forme de dalle - Condition de bord incurvé: 1
Portes | Category | Portes | N0
51_2V_PV_MV_XX_XX | Family | 51_2V_PV_MV_XX_XX | N0
2 x Type 1 | Type | Type 1 | N0
