Properties of the parts of a building model (IFC4), part 1 of 11

# File
Description: ViewDefinition [CoordinationView]
File name: B02_ARC.rvt.ifc
Time: 2025-08-20T10:49:29
Author: Foret Frédéric
Organization: CHU Caen
Written by: Revizto Hierarchic
Made in: ExportToIFC 5.16.0.37235

# IfcProject, CHU CAEN
Description: CHU CAEN

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 66.68 m

# IfcBuilding, B02_ARC.rvt
Description: CHU CAEN; LongName: B02_ARC.rvt; ElevationOfRefHeight: 0 m
Elément - Nom: B02_ARC.rvt; Type: Lien; Nom du fichier source: \\admin-srv2\Dir-Patr-inf\Commun\GestionPatrimoine\04_BIM\MN_PATRIMOINE\B02_DC\B02_ARC.rvt; Dernière Exportation: 2025-08-20T10:45:27; Dernier Exporté par: foret-f@chu-caen.fr
Revizto - Revizto Scene Data: base64(CAAqEzk0NTg5NzU4MzA5NDYyOTU1MzgyWlxcYWRtaW4tc3J2MlxEaXItUGF0ci1pbmZcQ29tbXVuXEdlc3Rpb25QYXRyaW1vaW5lXDA0X0JJTVxNTl9QQVRSSU1PSU5FXEIwMl9EQ1xCMDJfQVJDLnJ2dFFUtSExrah7VWoLQjAyX0FSQy5ydnR4AIABAIgBAA==); Revizto Version: 5.16.0.37235; Revizto Scene UID: 6159702377166386516; Revizto Export Logic Version: 2

# IfcBuildingStorey (5)
In: B02_ARC.rvt
Description: Building Storey
Name | Elevation (m)
N0 | 1.37408e-13
TT | 3.49205
AT | 6
S1 | -3
N0_FINI | 0.01

# IfcSpace (19)
In: B02_ARC.rvt
Elément - Type: RoomType; Fichier source: B02_ARC.rvt; Calque: N0_FINI
Informations sur le partage du travail des éléments - État des mises à jour des modèles: CurrentWithCentral; État du retrait: NotOwned; Créateur: foret-f; Dernière modification par: foret-f
Autre - Catégorie: Pièces; ID de phase: Existante
Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INTERNAL; Exporter au format IFC sous: IfcSpaceType
Données d'identification - Sous-projet: B02_ARC; Finition du mur: Peinture acrylique - satinée
Cotes - Hauteur de calcul: 0 m
Revizto - Room: yes
Analyse d'énergie - Contribution du plénum à l'éclairage: 20.00%; Charge d'éclairage réelle par surface: 0.00 W/m²; Charge de puissance réelle par surface: 0.00 W/m²; Valeurs de charge de chauffage: -1; Unités de charge d'éclairage: 0; Unités de charge de puissance: 0; Apport de chaleur sensible par personne: 73 W; Charge d'éclairage spécifiée: 0 W; Charge de puissance spécifiée: 0 W; Charge d'éclairage réelle: 0 W; Charge de puissance réelle: 0 W; Charge d'éclairage basée sur: -1; Charge de puissance basée sur: -1; Charge d'éclairage spécifiée par surface: 10.76 W/m²; Charge de puissance spécifiée par surface: 13.99 W/m²; Apport de chaleur latente par personne: 59 W; Apport de chaleur total par personne: 132 W; Surface par personne: 28.5714 m2; Nombre de personnes: 0
Phase de construction - Phase: Existante
Contraintes - Niveau: N0_FINI; Décalage inférieur: 0 m; Limite supérieure: N0_FINI
Name | Elément, Nom | Value = Authoring Tool Id | Données d'identification, Nom | Finition du plafond | Finition du sol | Numéro | Hauteur non liée (m) = Décalage limite (m) | Périmètre (m) | Surface (m2)
BUREAU DC-N0-010 | BUREAU DC-N0-010 | 499742 | BUREAU | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-010 | 2.5 | 21.3445 | 27.1881
BUREAU DC-N0-011 | BUREAU DC-N0-011 | 500291 | BUREAU | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-011 | 2.5 | 21.5086 | 28.1854
BUREAU DC-N0-012 | BUREAU DC-N0-012 | 500294 | BUREAU | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-012 | 2.5 | 21.4842 | 28.1751
DETENTE DC-N0-013 | DETENTE DC-N0-013 | 500297 | DETENTE | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-013 | 2.5 | 17.0737 | 16.0146
TGBT DC-N0-014 | TGBT DC-N0-014 | 500300 | TGBT | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-014 | 2.5 | 7.88084 | 3.86856
CIRCULATION DC-N0-C003 | CIRCULATION DC-N0-C003 | 500303 | CIRCULATION | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-C003 | 2.4 | 20.2204 | 14.3025
CIRCULATION DC-N0-C001 | CIRCULATION DC-N0-C001 | 500306 | CIRCULATION | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-C001 | 2.4 | 45.5887 | 42.9687
SANITAIRE DC-N0-009 | SANITAIRE DC-N0-009 | 500309 | SANITAIRE | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+ Remontée de sol | DC-N0-009 | 2.49557 | 7.83386 | 3.26853
SANITAIRE DC-N0-008 | SANITAIRE DC-N0-008 | 500312 | SANITAIRE | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+ Remontée de sol | DC-N0-008 | 2.5 | 7.78943 | 3.23416
SANITAIRE PMR DC-N0-007 | SANITAIRE PMR DC-N0-007 | 500315 | SANITAIRE PMR | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+ Remontée de sol | DC-N0-007 | 2.4384 | 9.66901 | 5.76631
BOX DC-N0-006 | BOX DC-N0-006 | 500318 | BOX | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-006 | 2.5 | 10.1885 | 6.11135
BOX DC-N0-005 | BOX DC-N0-005 | 500321 | BOX | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-005 | 2.5 | 10.5747 | 6.23069
BUREAU DC-N0-004 | BUREAU DC-N0-004 | 500324 | BUREAU | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-004 | 2.5 | 21.4644 | 24.7439
RESERVE DC-N0-015 | RESERVE DC-N0-015 | 500327 | RESERVE | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-015 | 2.5 | 9.89611 | 5.44421
CIRCULATION DC-N0-C002 | CIRCULATION DC-N0-C002 | 500330 | CIRCULATION | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-C002 | 2.4 | 17.0188 | 8.53715
SALLE DE REUNION DC-N0-001 | SALLE DE REUNION DC-N0-001 | 500333 | SALLE DE REUNION | acoustique de 39dB + Plaques de platres perforées | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-001 | 2.5 | 29.1988 | 51.5697
BUREAU DC-N0-003 | BUREAU DC-N0-003 | 500336 | BUREAU | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-003 | 2.5 | 20.1799 | 20.4097
DEGAGEMENT DC-N0-016 | DEGAGEMENT DC-N0-016 | 500342 | DEGAGEMENT | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-016 | 2.4 | 5.25686 | 1.68807
BUREAU DC-N0-002 | BUREAU DC-N0-002 | 500357 | BUREAU | 600 x 600mm en fibres minérales-acoustique de 39dB | PVC hétérogène acoustique U4 P3 C2+Plinthe PVC 100 mm | DC-N0-002 | 2.5 | 18.308 | 20.9391

# IfcBuildingElementPart (663)
In: B02_ARC.rvt
Elément - Fichier source: B02_ARC.rvt
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
Pièces | Category | Pièces | N0_FINI
Murs | Category | Murs | N0_FINI
Mur de base | Family | Mur de base | N0_FINI
23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | Type | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0_FINI
23_CLS_95/70_1BA13_EIXX_31db | Type | 23_CLS_95/70_1BA13_EIXX_31db | N0_FINI
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 284059 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 0; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 19.4965 m2; Volume: 1.85216 m3; Longueur: 6.285 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 284063 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 0; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.62 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 2.87205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 17.8464 m2; Volume: 1.6954 m3; Longueur: 6.29379 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 284067 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 0; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 17.3374 m2; Volume: 1.64699 m3; Longueur: 6.27699 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 285560 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 0; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 15.2349 m2; Volume: 1.4473 m3; Longueur: 4.97619 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 285989 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 0; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 18.7223 m2; Volume: 1.77833 m3; Longueur: 7.26257 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 286118 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 0; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 15.0178 m2; Volume: 1.42624 m3; Longueur: 4.90564 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 288576 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.842 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 2.65005 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 5.38843 m2; Volume: 0.511497 m3; Longueur: 2.83139 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 288745 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.661106 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 2.83095 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 3.39848 m2; Volume: 0.322434 m3; Longueur: 1.95222 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 288900 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 19.7093 m2; Volume: 1.87106 m3; Longueur: 6.32216 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 291349 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 2; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 0.976279 m2; Volume: 0.0926135 m3; Longueur: 0.929811 m; Reste concentrique: yes; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C; Graphismes - Marque centrale visible: no
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 291738 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 2; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 2.10035 m2; Volume: 0.199353 m3; Longueur: 1.42095 m; Reste concentrique: yes; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C; Graphismes - Marque centrale visible: no
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 299029 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 2; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 8.46587 m2; Volume: 0.804257 m3; Longueur: 2.75437 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 299158 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 2; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 8.46587 m2; Volume: 0.804257 m3; Longueur: 2.75437 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 299489 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 2; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 2.62249 m2; Volume: 0.248876 m3; Longueur: 1.56062 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 313408 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 2; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 9.06336 m2; Volume: 0.860737 m3; Longueur: 4.83311 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 316068 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 0; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 1.78113 m2; Volume: 0.168704 m3; Longueur: 1.36582 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 359312 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 2; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Limite de pièce: yes; Cotes - Surface: 17.2451 m2; Volume: 1.63004 m3; Longueur: 6.07902 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 360081 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 2; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 2.75 m; Limite de pièce: yes; Cotes - Surface: 1.50555 m2; Volume: 0.135811 m3; Longueur: 0.574797 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 361466 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 0; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Limite de pièce: yes; Cotes - Surface: 9.21826 m2; Volume: 0.875734 m3; Longueur: 3.14134 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 361651 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 0; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 2.75 m; Limite de pièce: yes; Cotes - Surface: 1.78594 m2; Volume: 0.169502 m3; Longueur: 0.60679 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
Mur de base | 23_CLS_95/70_1BA13_EIXX_31db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 362167 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_95/70_1BA13_EIXX_31db; Famille: 23_CLS_95/70_1BA13_EIXX_31db; Type: 23_CLS_95/70_1BA13_EIXX_31db; ID du type: 23_CLS_95/70_1BA13_EIXX_31db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 6.48102 m2; Volume: 0.615548 m3; Longueur: 2.15717 m; Type de Revit - Id: 283330; Nom: 23_CLS_95/70_1BA13_EIXX_31db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_95/70_1BA13_EIXX_31db; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22 + Isolant 10; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 3; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.095 m; 01RVZ_CLASSIFICATIONS: 23_CLOISON; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE C
23_CLS_152/100_PAREMENT_2BA13_EI60_41db | Type | 23_CLS_152/100_PAREMENT_2BA13_EI60_41db | N0_FINI
Mur de base | 23_CLS_152/100_PAREMENT_2BA13_EI60_41db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 284071 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Famille: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; ID du type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 0; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 13.226 m2; Volume: 2.0102 m3; Longueur: 4.28902 m; Type de Revit - Id: 295601; Nom: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Note d'identification: 23_CLOISON; Commentaires du type: Int. Brique 110 mm; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 0; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 0; Largeur: 0.152 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE D
Mur de base | 23_CLS_152/100_PAREMENT_2BA13_EI60_41db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 296506 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Famille: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; ID du type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 10.0192 m2; Volume: 1.52291 m3; Longueur: 3.16022 m; Type de Revit - Id: 295601; Nom: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Note d'identification: 23_CLOISON; Commentaires du type: Int. Brique 110 mm; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 0; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 0; Largeur: 0.152 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE D
Mur de base | 23_CLS_152/100_PAREMENT_2BA13_EI60_41db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 297364 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Famille: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; ID du type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 2.61522 m2; Volume: 0.397237 m3; Longueur: 0.831749 m; Reste concentrique: yes; Type de Revit - Id: 295601; Nom: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Note d'identification: 23_CLOISON; Commentaires du type: Int. Brique 110 mm; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 0; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 0; Largeur: 0.152 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE D; Graphismes - Marque centrale visible: no
Mur de base | 23_CLS_152/100_PAREMENT_2BA13_EI60_41db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 312521 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Famille: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; ID du type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 2; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 4.03869 m2; Volume: 0.613847 m3; Longueur: 1.38632 m; Type de Revit - Id: 295601; Nom: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Note d'identification: 23_CLOISON; Commentaires du type: Int. Brique 110 mm; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 0; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 0; Largeur: 0.152 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE D
Mur de base | 23_CLS_152/100_PAREMENT_2BA13_EI60_41db | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 435124 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Famille: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; ID du type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: PARTITIONING; Exporter au format IFC sous: IfcWallType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 14.8774 m2; Volume: 2.26102 m3; Longueur: 4.81644 m; Type de Revit - Id: 295601; Nom: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Note d'identification: 23_CLOISON; Commentaires du type: Int. Brique 110 mm; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 0; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 0; Largeur: 0.152 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE D
43-PAR_BA13 | Type | 43-PAR_BA13 | N0_FINI
23_CCL_115mm | Type | 23_CCL_115mm | N0_FINI
