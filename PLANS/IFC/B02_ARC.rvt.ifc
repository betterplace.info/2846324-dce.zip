Properties of the parts of a building model (IFC4), part 5 of 11

# IfcBuildingElementPart (663)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 382722 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 383123 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 383496 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 383631 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 383720 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 383909 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 384050 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 384251 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 396061 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 396064 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 396067 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 396070 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 396117 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 396120 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 396123 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 396126 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 396129 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 396132 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 396135 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 396174 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 397799 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 397926 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 398009 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 550 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 399195 | Fenêtres | B02_ARC | Autre - Famille et type: 550; Famille: 550; Type: 550; ID du type: 550; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.34002 m2; Volume: 0.0220146 m3; Type de Revit - Id: 377501; Nom: 550; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 550; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.55 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI; Données d'identification - Identifiant: 3
590 | Type | 590 | N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 389544 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
44 x XXX_VIDE FENETRE | Instance | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 389517 | Fenêtres | Famille : Fenêtres : XXX_VIDE FENETRE | Autre - Nom de la famille: XXX_VIDE FENETRE; Données d'identification - Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Paramètres IFC - Exporter le type au format IFC: 0; Propriétés analytiques - Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Contraintes - Elévation par défaut: 0 m; Cotes - L_1: 0.5902 m; L_2: 1.2017 m
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 389742 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 389849 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 389950 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 390129 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 390252 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 390385 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 390544 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 390649 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 390788 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 390877 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 391116 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 391213 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 391352 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0481 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 392917 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 393054 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 393147 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 393236 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 393355 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 393446 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 393535 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 393766 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 393891 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 393982 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 394107 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 394234 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 394435 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 394558 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
XXX_VIDE FENETRE | 590 | XXX_VIDE FENETRE | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 394645 | Fenêtres | B02_ARC | Autre - Famille et type: 590; Famille: 590; Type: 590; ID du type: 590; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: WINDOW; Exporter au format IFC sous: IfcWindowType; Revizto - Architecture: yes; Cotes - Surface: 1.40401 m2; Volume: 0.0230207 m3; Type de Revit - Id: 389517; Nom: 590; Catégorie: Fenêtres; Exporter le type au format IFC: 0; Sous-projet: Famille : Fenêtres : XXX_VIDE FENETRE; Nom de la famille: XXX_VIDE FENETRE; Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Elévation par défaut: 0 m; L_1: 0.5902 m; L_2: 1.2017 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Décalage par rapport à l'hôte: 1.0319 m; Hôte: Niveau : N0_FINI
