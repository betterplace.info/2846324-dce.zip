Properties of the parts of a building model (IFC4), part 10 of 11

# IfcBuildingElementPart (663)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 570463 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_95/70_1BA13_EIXX_31db; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 570465 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_95/70_1BA13_EIXX_31db; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 570466 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_95/70_1BA13_EIXX_31db; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 571077 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 43-PAR_BA13; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 571374 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 43-PAR_BA13; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
72_PATERE_HEWI SERIE 477 | Colour - 92 Anthracite grey | 72_PATERE_HEWI SERIE 477 | N0 | CurrentWithCentral | NotOwned | foret-f | 571548 | Mobilier | 2021_015 | Autre - Famille et type: Colour - 92 Anthracite grey; Famille: Colour - 92 Anthracite grey; Type: Colour - 92 Anthracite grey; ID du type: Colour - 92 Anthracite grey; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.00727641 m2; Volume: 0.0000555945 m3; Type de Revit - Id: 566101; Nom: Colour - 92 Anthracite grey; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_PATERE_HEWI SERIE 477; Nom de la famille: 72_PATERE_HEWI SERIE 477; Nom du type: Colour - 92 Anthracite grey; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://bimobject.com/hewi/product/477-90-045; BIMobject category: Sanitary Accessories; BIMobject category code: sanitary-accessories1; BIMobject main category: Sanitary; BIMobject main category code: sanitary; Brand url: http://www.hewi.com; Design country: Germany; Nominal height: 0 m; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Sanitary; Product group: Hooks, Walking aid holders; Product url: https://catalog.hewi.com/en/-477.90.045; QR code: http://bimobject.com/hewi/product/477-90-045; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Product SKU: 477-90-045; Technical description: https://catalog.hewi.com/en/-477.90.045; Uniclass 1.4 Code: L721; Uniclass 1.4 Description: Sanitary equipment; Uniclass 2.0 Code: PR-31-75; Uniclass 2.0 Description: Sanitary Accessories; UNSPSC Code: 301815; Weight Net (Kg): 0; Nominal width: 0 m; Date Created: 2020/12/02; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 92 Anthracite grey; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.5; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Mur de base : 43-PAR_BA13; Élévation par rapport au niveau: 1.65 m; Niveau de nomenclature: N0
72_VITRINE D'AFFICHAGE_GEN | Family | 72_VITRINE D'AFFICHAGE_GEN | N0
Ursus 2x1 | Type | Ursus 2x1 | N0
72_VITRINE D'AFFICHAGE_GEN | Ursus 2x1 | 72_VITRINE D'AFFICHAGE_GEN | N0 | CurrentWithCentral | NotOwned | foret-f | 578041 | Mobilier | 2021_015 | Autre - Famille et type: Ursus 2x1; Famille: Ursus 2x1; Type: Ursus 2x1; ID du type: Ursus 2x1; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 3.44339 m2; Volume: 0.0179361 m3; Type de Revit - Id: 575992; Nom: Ursus 2x1; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : 72_VITRINE D'AFFICHAGE_GEN; Nom de la famille: 72_VITRINE D'AFFICHAGE_GEN; Nom du type: Ursus 2x1; Hauteur: 0 m; Elévation par défaut: 1.2192 m; Fabricant: Boxicon AB; URL: https://www.boxicon.se; Material: RAL 7001; Glass: Glass; Ursus Entrance Board: 955x1755; Weight: 3.3; Author: ProdLib; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.4; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Garde-corps : 43_PLINTHE 100mm; Élévation par rapport au niveau: 1.78785 m; Niveau de nomenclature: N0
72_VITRINE D'AFFICHAGE_GEN | Instance | 72_VITRINE D'AFFICHAGE_GEN | N0 | CurrentWithCentral | NotOwned | foret-f | 575992 | Mobilier | Famille : Mobilier : 72_VITRINE D'AFFICHAGE_GEN | Autre - Nom de la famille: 72_VITRINE D'AFFICHAGE_GEN; Ursus Entrance Board: 955x1755; Weight: 3.3; Données d'identification - Nom du type: Ursus 2x1; Fabricant: Boxicon AB; URL: https://www.boxicon.se; Author: ProdLib; Cotes - Hauteur: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Contraintes - Elévation par défaut: 1.2192 m; Matériaux et finitions - Glass: Glass; Material: RAL 7001
Sanitary_Accessories_HEWI_HEWI-Hinged-support-rail-rotatable-801-5.0001 | Family | Sanitary_Accessories_HEWI_HEWI-Hinged-support-rail-rotatable-801-5.0001 | N0
Default - please load Revit Family Type Catalog | Type | Default - please load Revit Family Type Catalog | N0
Sanitary_Accessories_HEWI_HEWI-Hinged-support-rail-rotatable-801-5.0001 | Default - please load Revit Family Type Catalog | Sanitary_Accessories_HEWI_HEWI-Hinged-support-rail-rotatable-801-5.0001 | N0 | CurrentWithCentral | NotOwned | foret-f | 584252 | Mobilier | 2021_015 | Autre - Famille et type: Default - please load Revit Family Type Catalog; Famille: Default - please load Revit Family Type Catalog; Type: Default - please load Revit Family Type Catalog; ID du type: Default - please load Revit Family Type Catalog; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 0.187318 m2; Volume: 0.00319489 m3; Type de Revit - Id: 584250; Nom: Default - please load Revit Family Type Catalog; Catégorie: Mobilier; Exporter le type au format IFC: 0; Sous-projet: Famille : Mobilier : Sanitary_Accessories_HEWI_HEWI-Hinged-support-rail-rotatable-801-5.0001; Nom de la famille: Sanitary_Accessories_HEWI_HEWI-Hinged-support-rail-rotatable-801-5.0001; Nom du type: Default - please load Revit Family Type Catalog; Elévation par défaut: 1.2192 m; Titre OmniClass: Equipment and Furnishings; Numéro OmniClass: 23.40.00.00; Edition number: 1; Product data url: https://www.bimobject.com/hewi/product/801-50-121; BIMobject category: Accessories; Design country: Germany; IFC Classification: Sanitary Terminal; Manufacturer country: Germany; Manufacturer name: HEWI; Material main: Polyamide; NBS Reference Code: 31-75; NBS Reference Description: Sanitary Accessories; OmniClass Code: 23-19 31 17; OmniClass Description: Sanitary Room Units; Product family: Accessibility; Product group: Hinged and stationary support rails; Product url: https://catalog.hewi.com/en/-801.50.121; QR code: https://www.bimobject.com/hewi/product/801-50-121; Product SKU: 801-50-121; Technical description: https://catalog.hewi.com/en/-801.50.121; UNSPSC Code: 301815; Date Created: 2021/07/12; Date Updated: 2025/01/20; Version: 2; Material 1: HEWI - 18 Mustard yellow; Installation instructions: https://catalog.hewi.com/en/-801.50.121; Material secondary: Steel; Product name: HEWI Hinged support rail, rotatable 801-50-121; Material 2: HEWI - Black; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.5.2; GEM_ROP_REPERE CCTP: -; Contraintes - Niveau: N0; Hôte: Garde-corps : 43_PLINTHE REMONTE DE SOL; Élévation par rapport au niveau: 0.628002 m; Niveau de nomenclature: N0
Sols | Category | Sols | TT
Sol | Family | Sol | TT
14_ISOLATION TT | Type | 14_ISOLATION TT | TT
Sol | 14_ISOLATION TT | Sol | TT | CurrentWithCentral | NotOwned | foret-f | 425733 | Sols | B02_ARC | Autre - Famille et type: 14_ISOLATION TT; Famille: 14_ISOLATION TT; Type: 14_ISOLATION TT; ID du type: 14_ISOLATION TT; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: TT; Décalage par rapport au niveau: -0.02 m; Cotes - Surface: 114.951 m2; Volume: 11.4951 m3; Périmètre: 48.6866 m; Epaisseur: 0.1 m; Elévation au niveau du noyau inférieur: 3.37205 m; Elévation au niveau du noyau supérieur: 3.47205 m; Elévation en haut: 3.47205 m; Elévation à la base: 3.37205 m; Type de Revit - Id: 425735; Nom: 14_ISOLATION TT; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 14_ISOLATION TT; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Matériau structurel: 34_ISOLANT TT; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Données d'identification - A une association: no; Modification de la forme de dalle - Condition de bord incurvé: 1
Sol | 14_ISOLATION TT | Sol | TT | CurrentWithCentral | NotOwned | foret-f | 426244 | Sols | B02_ARC | Autre - Famille et type: 14_ISOLATION TT; Famille: 14_ISOLATION TT; Type: 14_ISOLATION TT; ID du type: 14_ISOLATION TT; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: TT; Décalage par rapport au niveau: -0.02 m; Cotes - Surface: 99.7583 m2; Volume: 9.97571 m3; Périmètre: 44.1493 m; Epaisseur: 0.1 m; Elévation au niveau du noyau inférieur: 3.37205 m; Elévation au niveau du noyau supérieur: 3.47205 m; Elévation en haut: 3.47205 m; Elévation à la base: 3.37205 m; Type de Revit - Id: 425735; Nom: 14_ISOLATION TT; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 14_ISOLATION TT; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Matériau structurel: 34_ISOLANT TT; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Données d'identification - A une association: no
Sol | 14_ISOLATION TT | Sol | TT | CurrentWithCentral | NotOwned | foret-f | 426509 | Sols | B02_ARC | Autre - Famille et type: 14_ISOLATION TT; Famille: 14_ISOLATION TT; Type: 14_ISOLATION TT; ID du type: 14_ISOLATION TT; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: TT; Décalage par rapport au niveau: -0.02 m; Cotes - Surface: 100.36 m2; Volume: 10.036 m3; Périmètre: 44.357 m; Epaisseur: 0.1 m; Elévation au niveau du noyau inférieur: 3.37205 m; Elévation au niveau du noyau supérieur: 3.47205 m; Elévation en haut: 3.47205 m; Elévation à la base: 3.37205 m; Type de Revit - Id: 425735; Nom: 14_ISOLATION TT; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 14_ISOLATION TT; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Matériau structurel: 34_ISOLANT TT; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Données d'identification - A une association: no
Sol | 14_ISOLATION TT | Sol | TT | CurrentWithCentral | NotOwned | foret-f | 426879 | Sols | B02_ARC | Autre - Famille et type: 14_ISOLATION TT; Famille: 14_ISOLATION TT; Type: 14_ISOLATION TT; ID du type: 14_ISOLATION TT; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: TT; Décalage par rapport au niveau: -0.02 m; Cotes - Surface: 136.661 m2; Volume: 13.6679 m3; Périmètre: 55.2797 m; Epaisseur: 0.1 m; Elévation au niveau du noyau inférieur: 3.37205 m; Elévation au niveau du noyau supérieur: 3.47205 m; Elévation en haut: 3.47205 m; Elévation à la base: 3.37205 m; Type de Revit - Id: 425735; Nom: 14_ISOLATION TT; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 14_ISOLATION TT; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Matériau structurel: 34_ISOLANT TT; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Données d'identification - A une association: no
Sol | 14_ISOLATION TT | Sol | TT | CurrentWithCentral | NotOwned | foret-f | 427273 | Sols | B02_ARC | Autre - Famille et type: 14_ISOLATION TT; Famille: 14_ISOLATION TT; Type: 14_ISOLATION TT; ID du type: 14_ISOLATION TT; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: TT; Décalage par rapport au niveau: -0.412 m; Cotes - Surface: 39.8584 m2; Volume: 3.98584 m3; Périmètre: 47.6216 m; Epaisseur: 0.1 m; Elévation au niveau du noyau inférieur: 2.98005 m; Elévation au niveau du noyau supérieur: 3.08005 m; Elévation en haut: 3.08005 m; Elévation à la base: 2.98005 m; Type de Revit - Id: 425735; Nom: 14_ISOLATION TT; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 14_ISOLATION TT; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Matériau structurel: 34_ISOLANT TT; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Données d'identification - A une association: no
Sol | 14_ISOLATION TT | Sol | TT | CurrentWithCentral | NotOwned | foret-f | 429483 | Sols | B02_ARC | Autre - Famille et type: 14_ISOLATION TT; Famille: 14_ISOLATION TT; Type: 14_ISOLATION TT; ID du type: 14_ISOLATION TT; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: TT; Décalage par rapport au niveau: 0.338961 m; Cotes - Surface: 7.08712 m2; Volume: 0.708712 m3; Périmètre: 26.8419 m; Epaisseur: 0.1 m; Elévation au niveau du noyau inférieur: 3.73101 m; Elévation au niveau du noyau supérieur: 3.83101 m; Elévation en haut: 3.83101 m; Elévation à la base: 3.73101 m; Type de Revit - Id: 425735; Nom: 14_ISOLATION TT; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 14_ISOLATION TT; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Matériau structurel: 34_ISOLANT TT; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Données d'identification - A une association: no; Modification de la forme de dalle - Condition de bord incurvé: 1
Murs | Category | Murs | TT
Mur de base | Family | Mur de base | TT
14_ISOLATION TT VERTICAL | Type | 14_ISOLATION TT VERTICAL | TT
Mur de base | 14_ISOLATION TT VERTICAL | Mur de base | TT | CurrentWithCentral | NotOwned | foret-f | 428131 | Murs | B02_ARC | Autre - Famille et type: 14_ISOLATION TT VERTICAL; Famille: 14_ISOLATION TT VERTICAL; Type: 14_ISOLATION TT VERTICAL; ID du type: 14_ISOLATION TT VERTICAL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.412 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: TT; Hauteur non contrainte: 0.392 m; Limite de pièce: yes; Cotes - Surface: 5.10659 m2; Volume: 0.510443 m3; Longueur: 13.0215 m; Reste concentrique: yes; Type de Revit - Id: 427402; Nom: 14_ISOLATION TT VERTICAL; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 14_ISOLATION TT VERTICAL; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Commentaires du type: Extérieur voile BA 20; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 1; Retournement aux extrémités: 1; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Graphismes - Marque centrale visible: no

# IfcBuildingElementProxy (10)
In: B02_ARC.rvt
Elément - Fichier source: B02_ARC.rvt
Informations sur le partage du travail des éléments - État des mises à jour des modèles: CurrentWithCentral; État du retrait: NotOwned; Créateur: foret-f; Dernière modification par: foret-f
Name | Elément, Type | Elément, Nom | Calque | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC = Type de Revit, Exporter le type au format IFC | Données d'identification, Sous-projet | Type de Revit, Id | Type de Revit, Catégorie | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
Mur-rideau | Simple panneau | Mur-rideau | N0_FINI | 366562 | Murs | Simple panneau | 0 | B02_ARC | 149857 | Murs | Types de murs-rideaux | Mur-rideau | Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Lié au volume: no; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -1.26205 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 2.23 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 9.37715 m2; Longueur: 4.205 m; Type de Revit - Note d'identification: 22_MUR RIDEAU; Fonction: 0; Régler pour la taille du meneau: yes; Espacement: 2 m; Présentation: 0; Condition de jonction: 3; Panneau de mur-rideau: Vitré; Encastrement automatique: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Quadrillage horizontal - Décaler: 0 m; Angle: 0 deg; Nombre: 4; Justification: 1; Quadrillage vertical - Décaler: 0 m; Angle: 0 deg; Nombre: 4; Justification: 4
Mur-rideau | Simple panneau | Mur-rideau | N0_FINI | 368043 | Murs | Simple panneau | 0 | B02_ARC | 149857 | Murs | Types de murs-rideaux | Mur-rideau | Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Lié au volume: no; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -1.26178 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 2.23028 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 1.51576 m2; Longueur: 0.679629 m; Type de Revit - Note d'identification: 22_MUR RIDEAU; Fonction: 0; Régler pour la taille du meneau: yes; Espacement: 2 m; Présentation: 0; Condition de jonction: 3; Panneau de mur-rideau: Vitré; Encastrement automatique: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Quadrillage horizontal - Décaler: 0 m; Angle: 0 deg; Nombre: 4; Justification: 1; Quadrillage vertical - Décaler: 0 m; Angle: 0 deg; Nombre: 4; Justification: 4
XXX_VIDE FENETRE | Instance | XXX_VIDE FENETRE | N0_FINI | 389517 | Fenêtres |  |  | Famille : Fenêtres : XXX_VIDE FENETRE | Autre - Nom de la famille: XXX_VIDE FENETRE; Données d'identification - Nom du type: 590; Note d'identification: 19_RÃ‰SERVATION ,TREMIE, CAROTTAGE; Paramètres IFC - Exporter le type au format IFC: 0; Propriétés analytiques - Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Contraintes - Elévation par défaut: 0 m; Cotes - L_1: 0.5902 m; L_2: 1.2017 m
Niveau | Ligne du Niveau | Niveau | <NoLevel> | 608 | Niveaux | Ligne du Niveau | 0 | Niveaux et quadrillages partagés | 602 | Niveaux | Types de niveaux | Niveau | Données d'identification - Nom: N0; Structure: no; Etage de bâtiment: yes; Contraintes - Elévation: 1.37408e-13 m; Cotes - Hauteur de calcul: 0 m; Type de Revit - Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes; Référence de l'élévation: 0; Symbole: Marqueur de niveau - Point triangulaire; Motif des lignes: Tiret point; Couleur: 12632256; Epaisseur des lignes: 1
Niveau | Ligne du Niveau | Niveau | <NoLevel> | 1910 | Niveaux | Ligne du Niveau | 0 | Niveaux et quadrillages partagés | 602 | Niveaux | Types de niveaux | Niveau | Données d'identification - Nom: TT; Structure: no; Etage de bâtiment: yes; Contraintes - Elévation: 3.49205 m; Cotes - Hauteur de calcul: 0 m; Type de Revit - Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes; Référence de l'élévation: 0; Symbole: Marqueur de niveau - Point triangulaire; Motif des lignes: Tiret point; Couleur: 12632256; Epaisseur des lignes: 1
Niveau | Ligne du Niveau | Niveau | <NoLevel> | 2049 | Niveaux | Ligne du Niveau | 0 | Niveaux et quadrillages partagés | 602 | Niveaux | Types de niveaux | Niveau | Données d'identification - Nom: AT; Structure: no; Etage de bâtiment: yes; Contraintes - Elévation: 6 m; Cotes - Hauteur de calcul: 0 m; Type de Revit - Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes; Référence de l'élévation: 0; Symbole: Marqueur de niveau - Point triangulaire; Motif des lignes: Tiret point; Couleur: 12632256; Epaisseur des lignes: 1
Niveau | Ligne du Niveau | Niveau | <NoLevel> | 255208 | Niveaux | Ligne du Niveau | 0 | Niveaux et quadrillages partagés | 602 | Niveaux | Types de niveaux | Niveau | Données d'identification - Nom: S1; Structure: no; Etage de bâtiment: yes; Contraintes - Elévation: -3 m; Cotes - Hauteur de calcul: 0 m; Type de Revit - Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes; Référence de l'élévation: 0; Symbole: Marqueur de niveau - Point triangulaire; Motif des lignes: Tiret point; Couleur: 12632256; Epaisseur des lignes: 1
Niveau | Ligne du Niveau | Niveau | <NoLevel> | 279559 | Niveaux | Ligne du Niveau | 0 | Niveaux et quadrillages partagés | 602 | Niveaux | Types de niveaux | Niveau | Données d'identification - Nom: N0_FINI; Structure: no; Etage de bâtiment: yes; Contraintes - Elévation: 0.01 m; Cotes - Hauteur de calcul: 0 m; Type de Revit - Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes; Référence de l'élévation: 0; Symbole: Marqueur de niveau - Point triangulaire; Motif des lignes: Tiret point; Couleur: 12632256; Epaisseur des lignes: 1
Ligne de quadrillage | Ligne de quadrillage | Ligne de quadrillage | <NoLevel> | 366835 | Murs: Quadrillage du mur-rideau |  |  | B02_ARC | Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante
Ligne de quadrillage | Ligne de quadrillage | Ligne de quadrillage | <NoLevel> | 367174 | Murs: Quadrillage du mur-rideau |  |  | B02_ARC | Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante

# IfcCovering (14)
In: B02_ARC.rvt
ROP_SUIVIE DE CHANTIER - Installation ?: no
Elément - Type: 44_SOL TYPE A; Nom: Sol; Fichier source: B02_ARC.rvt
Informations sur le partage du travail des éléments - État des mises à jour des modèles: CurrentWithCentral; État du retrait: NotOwned; Créateur: foret-f; Dernière modification par: foret-f
Autre - Catégorie: Sols; Famille et type: 44_SOL TYPE A; Famille: 44_SOL TYPE A; Type: 44_SOL TYPE A; ID du type: 44_SOL TYPE A
Paramètres IFC - Exporter au format IFC: 0
Données d'identification - Sous-projet: 2021_015; A une association: no
Revizto - Architecture: yes; Structure: yes
Contraintes - Lié au volume: no; Limite de pièce: yes
Cotes - Epaisseur: 0.002 m; Elévation au niveau du noyau inférieur: 0.008 m; Elévation au niveau du noyau supérieur: 0.01 m; Elévation en haut: 0.01 m; Elévation à la base: 0.008 m
Type de Revit - Id: 319070; Nom: 44_SOL TYPE A; Catégorie: Sols; Exporter le type au format IFC: 1; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 44_SOL TYPE A; Note d'identification: 44_SOL FINITION; Exporter le type au format IFC sous: IfcCoveringType; Matériau structurel: 44_SOL TYPE A; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Type: Type prédéfini d'IFC: FLOORING; Epaisseur par défaut: 0.002 m
Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3
Phase de construction - Phase de création: Existante
Structure - Structure: no
Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Name | Calque = Niveau | Value = Authoring Tool Id | Type prédéfini d'IFC | Exporter au format IFC sous | Décalage par rapport au niveau (m) | Périmètre (m) | Surface (m2) | Volume (m3)
Sol | N0_FINI | 319295 | FLOORING | IfcCoveringType | 0 | 74.2243 | 59.9999 | 0.12 | Modification de la forme de dalle - Condition de bord incurvé: 1
Sol | N0_FINI | 319527 | FLOORING | IfcCoveringType | 0 | 9.73563 | 5.79797 | 0.0115959
Sol | N0_FINI | 319575 | FLOORING | IfcCoveringType | 0 | 7.85466 | 3.26413 | 0.00652826
Sol | N0_FINI | 319621 | FLOORING | IfcCoveringType | 0 | 7.87477 | 3.27608 | 0.00655216
Sol | N0_FINI | 319798 | FLOORING | IfcCoveringType | 0 | 20.2465 | 20.4463 | 0.0408926
Sol | N0_FINI | 319839 | FLOORING | IfcCoveringType | 0 | 18.374 | 20.97 | 0.0419399
Sol | N0_FINI | 319887 | FLOORING | IfcCoveringType | 0 | 29.2648 | 51.6005 | 0.103201
Sol | N0_FINI | 319961 | FLOORING | IfcCoveringType | 0 | 10.3707 | 6.14836 | 0.0122967
Sol | N0_FINI | 319999 | FLOORING | IfcCoveringType | 0 | 10.6407 | 6.26151 | 0.012523
Sol | N0_FINI | 320065 | FLOORING | IfcCoveringType | 0 | 21.7068 | 27.4137 | 0.0548273
Sol | N0_FINI | 320112 | FLOORING | IfcCoveringType | 0 | 21.8701 | 28.3585 | 0.0567171
Sol | N0_FINI | 320186 | FLOORING | IfcCoveringType | 0 | 21.5502 | 28.2059 | 0.0564119
Sol | N0_FINI | 320221 | FLOORING | IfcCoveringType | 0 | 23.3099 | 20.0642 | 0.0401285
Sol | N0 | 412561 |  |  | 0.01 | 21.2088 | 24.62 | 0.04924

# IfcGeographicElement (5)
In: B02_ARC.rvt
Elément - Nom: Solide topographique; Fichier source: B02_ARC.rvt; Calque: N0
Informations sur le partage du travail des éléments - État des mises à jour des modèles: CurrentWithCentral; État du retrait: NotOwned; Créateur: foret-f; Dernière modification par: foret-f
Autre - Catégorie: Solide topographique
Paramètres IFC - Exporter au format IFC: 0
Données d'identification - Sous-projet: 2021_015_RAMPE
Contraintes - Niveau: N0; Lié au volume: no; Limite de pièce: yes; Décalage de la hauteur par rapport au niveau: 0 m
Cotes - Élévation à la base: -2.7 m
Type de Revit - Catégorie: Solide topographique; Exporter le type au format IFC: 0; Sous-projet: Types de solides topographiques; Nom de la famille: Solide topographique; Rugosité: 1; Coefficient d'absorbance: 0.1; Couleur vue détail faible: 0; Épaisseur par défaut: 2.7 m
Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3
Phase de construction - Phase de création: Existante
Name | Elément, Type = Famille et type = Famille = Autre, Type = ID du type = Nom = Nom du type | Value = Authoring Tool Id | Périmètre (m) | Surface (m2) | Volume (m3) | Id | Condition de bord incurvé
Solide topographique | Solide topographiquerevegetalisation | 483890 | 88.7611 | 118.326 | 280.228 | 484718 | 1 | Paramètres IFC - Type prédéfini d'IFC: EXTERNAL; Exporter au format IFC sous: IfcExternalSpatialElement
Solide topographique | Solide topographiquerevegetalisation | 489292 | 30.4749 | 56.262 | 129.867 | 484718 | 1 | Paramètres IFC - Type prédéfini d'IFC: EXTERNAL; Exporter au format IFC sous: IfcExternalSpatialElement
Solide topographique | VOIE CIRCULATION | 490580 | 43.0699 | 43.8513 | 88.7627 | 490582 | 0
Solide topographique | VOIE CIRCULATION | 491934 | 44.8492 | 62.0524 | 145.39 | 490582 | 1
Solide topographique | glacie | 492430 | 24.7768 | 4.873 | 10.0348 | 492432 | 0

# IfcPlate (98)
In: B02_ARC.rvt
Elément - Nom: Mur de base; Fichier source: B02_ARC.rvt
Informations sur le partage du travail des éléments - État des mises à jour des modèles: CurrentWithCentral; État du retrait: NotOwned; Créateur: foret-f; Dernière modification par: foret-f
Autre - Catégorie: Murs
Paramètres IFC - Exporter au format IFC: 0
Données d'identification - Sous-projet: 2021_015
Revizto - Architecture: yes; Structure: yes
Contraintes - Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Partie inférieure attachée: no; Partie supérieure attachée: no; Limite de pièce: yes
Type de Revit - Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Note d'identification: 23_CLOISON; Exporter le type au format IFC sous: IfcPlateType; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 0; Retournement aux extrémités: 0; Couleur vue détail faible: 0
Phase de création - Catégorie: Phases; Sous-projet: Paramètres des phases
Définition de la coupe transversale - Coupe transversale: 1
Structure - Structure: no; Utilisation structurelle: 0
Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015
Name | Installation ? | Elément, Type = Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Nom du type | Calque = Contrainte inférieure | Value = Authoring Tool Id | Type prédéfini d'IFC | Exporter au format IFC sous | Décalage inférieur (m) | Ligne de justification | Décalage supérieur (m) | Hauteur non contrainte (m) | Surface (m2) | Volume (m3) | Longueur (m) | Type de Revit, Id | Commentaires du type | Matériau structurel | Fonction | Largeur (m) | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Id | GEM_ROP_N°LOT | GEM_ROP_NOM DU LOT | GEM_ROP_LIGNE CCTP | GEM_ROP_REPERE CCTP | Type: Type prédéfini d'IFC
Mur de base | no | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0_FINI | 281098 | PARTITIONING | IfcWallType | -0.01 | 3 | -0.35 | 3.14205 | 49.3684 | 7.89272 | 20.7175 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT; Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0_FINI | 281619 | PARTITIONING | IfcWallType | -0.01 | 3 | -0.35 | 3.14205 | 19.6917 | 3.15063 | 6.26707 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT
Mur de base | no | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0_FINI | 282153 | PARTITIONING | IfcWallType | -0.01 | 3 | -0.35 | 3.14205 | 19.9725 | 3.19534 | 6.19598 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT
Mur de base | yes | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0_FINI | 282678 | PARTITIONING | IfcWallType | -0.01 | 3 | -0.35 | 3.14205 | 47.8778 | 7.6544 | 20.7615 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT; Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0_FINI | 282842 | PARTITIONING | IfcWallType | -0.01 | 3 | -0.872053 | 2.62 | 3.84007 | 0.614209 | 1.66655 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT
Mur de base | no | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0_FINI | 283192 | PARTITIONING | IfcWallType | -0.01 | 3 | -0.35 | 3.14205 | 10.1074 | 1.61643 | 3.21531 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT; Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0_FINI | 290416 | PARTITIONING | IfcWallType | -0.01 | 3 | -0.842 | 2.65005 | 1.01921 | 0.163008 | 0.544447 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT; Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0_FINI | 290623 | PARTITIONING | IfcWallType | -0.01 | 3 | -0.35 | 3.14205 | 1.16376 | 0.186155 | 0.39339 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT
Mur de base | no | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0_FINI | 389411 | PARTITIONING | IfcWallType | 0 | 3 | -0.35 | 3.13205 | 28.9099 | 4.62169 | 12.6348 | 280148 | Int. Brique 110 mm | 22-Isolation intérieur | 0 | 0.16 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE A | Contraintes - Contrainte supérieure: TT; Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 43-PAR_BA13 | N0_FINI | 287640 | BASE_PLATE | IfcPlateType | -0.01 | 3 | 0 | 2.75 | 1.15644 | 0.014455 | 0.420508 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE | Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 43-PAR_BA13 | N0_FINI | 287865 | BASE_PLATE | IfcPlateType | -0.01 | 3 | 0 | 2.75 | 1.20507 | 0.0150629 | 0.431942 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 289314 | BASE_PLATE | IfcPlateType | -0.01 | 3 | 0 | 2.41 | 9.16286 | 0.114533 | 3.79039 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 289435 | BASE_PLATE | IfcPlateType | -0.01 | 3 | 0 | 2.75 | 5.58685 | 0.0698356 | 2.03081 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 289625 | BASE_PLATE | IfcPlateType | -0.01 | 3 | 0 | 2.75 | 8.9446 | 0.1118 | 3.20111 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 289831 | BASE_PLATE | IfcPlateType | -0.01 | 3 | 0 | 2.51 | 8.27654 | 0.103455 | 3.28487 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 289963 | BASE_PLATE | IfcPlateType | -0.01 | 3 | 0 | 2.51 | 4.18181 | 0.0522723 | 1.66605 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 290114 | BASE_PLATE | IfcPlateType | -0.01 | 3 | 0 | 2.51 | 8.28142 | 0.103516 | 3.29931 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 290219 | BASE_PLATE | IfcPlateType | -0.01 | 3 | 0 | 2.51 | 1.45562 | 0.018194 | 0.580903 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 290766 | BASE_PLATE | IfcPlateType | -0.01 | 3 | 0 | 2.75 | 3.0291 | 0.0378634 | 1.15062 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE | Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 43-PAR_BA13 | N0_FINI | 291018 | BASE_PLATE | IfcPlateType | -0.01 | 3 | 0 | 2.41 | 0.349594 | 0.00436899 | 0.21246 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE | Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 43-PAR_BA13 | N0_FINI | 292399 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.439988 | 0.00513297 | 0.166213 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 292754 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.115568 | 0.00144348 | 0.0357421 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 292981 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.41412 | 0.00517634 | 0.166466 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 293263 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.100878 | 0.00126012 | 0.0304081 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 293650 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 9.99068 | 0.124876 | 3.63901 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE | Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 43-PAR_BA13 | N0_FINI | 293828 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 12.9398 | 0.161739 | 4.70513 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE | Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 43-PAR_BA13 | N0_FINI | 294005 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.259291 | 0.00324019 | 0.0880101 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE | Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 43-PAR_BA13 | N0_FINI | 294304 | BASE_PLATE | IfcPlateType | -0.01 | 3 | 0 | 2.75 | 20.0412 | 0.250501 | 7.27479 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE | Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 43-PAR_BA13 | N0_FINI | 294493 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.41 | 0.348939 | 0.00436056 | 0.133217 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 294626 | BASE_PLATE | IfcPlateType | 1.81719e-14 | 2 | 0 | 2.4 | 2.56293 | 0.0320322 | 1.06818 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 294630 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 2.37378 | 0.0296722 | 0.776942 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 294723 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.447884 | 0.00559855 | 0.1725 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 295432 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.62 | 0.578923 | 0.0072342 | 0.227142 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 297181 | BASE_PLATE | IfcPlateType | -0.01 | 3 | -0.35 | 3.14205 | 2.94967 | 0.0368659 | 0.932395 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE | Contraintes - Contrainte supérieure: TT; Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 43-PAR_BA13 | N0_FINI | 298005 | BASE_PLATE | IfcPlateType | -0.01 | 3 | -0.35 | 3.14205 | 4.51023 | 0.0563746 | 1.43536 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 2 | Nouvelle construction | 0 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE | Contraintes - Contrainte supérieure: TT; Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 43-PAR_BA13 | N0_FINI | 299218 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 5.43636 | 0.0679531 | 1.97682 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 299222 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 3.10329 | 0.0387899 | 2.15856 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 299226 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.51 | 2.60034 | 0.032503 | 1.89682 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 299230 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.51 | 5.13628 | 0.0642015 | 2.04626 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 299234 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 5.25177 | 0.0656458 | 1.9097 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE | Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
Mur de base | no | 43-PAR_BA13 | N0_FINI | 299239 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 5.61087 | 0.0701352 | 2.0528 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 299543 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.632509 | 0.00790636 | 0.242503 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 299616 | BASE_PLATE | IfcPlateType | -0.01 | 2 | 0 | 2.75 | 0.632512 | 0.00790639 | 0.242504 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE
Mur de base | no | 43-PAR_BA13 | N0_FINI | 299673 | BASE_PLATE | IfcPlateType | -0.01 | 3 | 0 | 2.75 | 0.255888 | 0.00319472 | 0.0804354 | 29328 | Ext. Brique 22 | 22-Plaque de platre | 1 | 0.0125 | 1 | Existante | 3 | 01 | MEUNUISERIES INTERIEURS | 12.1.1 | TYPE B | BASE_PLATE | Cotes - Reste concentrique: yes; Graphismes - Marque centrale visible: no
