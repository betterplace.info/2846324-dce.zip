Properties of the parts of a building model (IFC4), part 8 of 11

# IfcBuildingElementPart (663)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
51_2V_PV_MV_XX_XX | Type 1 | 51_2V_PV_MV_XX_XX | N0 | CurrentWithCentral | NotOwned | foret-f | 411454 | Portes | B02_ARC | Autre - Famille et type: Type 1; Famille: Type 1; Type: Type 1; ID du type: Type 1; Position in wall: 0.034 m; Floor build up: 0.15 m; Gap to shell construction left: 0.01 m; Gap to shell construction right: 0.01 m; Gap to shell construction lintel: 0.01 m; Reveal left: 0.02 m; Reveal right: 0.02 m; Reveal lintel: 0.02 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 7.40415 m2; Volume: 0.152246 m3; UP: 2; Largeur brute: 2.0234 m; Hauteur brute: 2.23 m; Largeur: 2.0234 m; Hauteur: 2.23 m; Outer frame height: 2.22 m; Outer frame width: 2.0034 m; Clear opening width: 1.8654 m; Type de Revit - Id: 411318; Nom: Type 1; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : 51_2V_PV_MV_XX_XX; Nom de la famille: 51_2V_PV_MV_XX_XX; Nom du type: Type 1; Note d'identification: 50_PORTE EXTERIEUR; Epaisseur: 0.06 m; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Identifiant du type: 28; Fermeture du mur: 0; Titre OmniClass: Doors; Numéro OmniClass: 23.30.10.00; Modèle: Schueco ADS 60; Fabricant: Schueco International KG; URL: www.schueco.com; Description: Schueco Aluminium Door System (ADS); Description de l'assemblage: Exterior Glazed Doors - Aluminum; Code d'assemblage: B2030110; SCal_Data: <?xml version="1.0" encoding="utf-8"?> <fields system="window" gridWidth="1" gridHeight="1" mergedFields=""> <field id="0" alias="DV_DOOR" glasstype="glass" dindirection="left" direction="inside"/> </fields>; SystemID: 200; Handle height: 1.05 m; Version number: 1.0; Thermal insulation standard: Highly thermally insulated; Edition number: 1; Opening type: Double-leaf, Inward-opening, Flush-fitted; Air permeability: Class 2; Burglar resistance: Class RC 2; Mechanical loading: Class 3; Sound insulation: to Rw ... dB; Thermal insulation: Uf to ... W/(m²K); Watertightness: Up to class 5A; Wind load resistance: Up to class C3; Long term functionality: Class 5; Façade insert unit: no; Family creation date: 04.2018; Frame: Alu; Areas of use: ...; Active leaf width: 1.1 m; Material: Aluminium; Glazing data: ...; Handles: yes; Outer frame extension left: 0 m; Outer frame extension lintel: 0 m; Outer frame extension right: 0 m; Product data url: https://www.bimobject.com/schueco/product/schueco_ads_60_inward_opening; __NOTE__: Data describes the optimum values of the entire system. The properites of a selected design option have to be determined on an individual basis!; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0; Décalage par rapport à l'hôte: -3.68879e-14 m; Elévation par défaut: 1.2192 m; Plan de construction: Niveau : N0; Niveau de nomenclature: N0; Données d'identification - Identifiant: 28; Graphismes - Leaf opening angle: 0 deg; Modèle analytique - RevT: 2.21 m; RevR: 2.0034 m; RevL: 2.0034 m; GapT: 2.22 m; GapR: 2.0134 m; GapL: 2.0134 m; F1_W: 1.1 m; F2_W: 0.9034 m; InFrH: 2.22 m; InFrW: 2.0034 m; Ins_Ex: 0 m; Ins_In: 0.034 m; Données - Glazing area: 3.01226 m2
51_2V_PV_MV_XX_XX | Instance | 51_2V_PV_MV_XX_XX | N0 | CurrentWithCentral | NotOwned | foret-f | 413066 | Portes | Famille : Portes : 51_2V_PV_MV_XX_XX | Cotes - Epaisseur: 0.06 m; Active leaf width: 1.1 m; Autre - Nom de la famille: 51_2V_PV_MV_XX_XX; Handle height: 1.05 m; Outer frame extension left: 0 m; Outer frame extension lintel: 0 m; Outer frame extension right: 0 m; Données d'identification - Nom du type: Type 1; Note d'identification: 50_PORTE EXTERIEUR; Titre OmniClass: Doors; Numéro OmniClass: 23.30.10.00; Modèle: Schueco ADS 60; Fabricant: Schueco International KG; URL: www.schueco.com; Description: Schueco Aluminium Door System (ADS); Description de l'assemblage: Exterior Glazed Doors - Aluminum; Code d'assemblage: B2030110; Family creation date: 04.2018; Product data url: https://www.bimobject.com/schueco/product/schueco_ads_60_inward_opening; Paramètres IFC - Exporter le type au format IFC: 0; Propriétés analytiques - Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Construction - Fermeture du mur: 0; Handles: yes; Modèle analytique - SCal_Data: <?xml version="1.0" encoding="utf-8"?> <fields system="window" gridWidth="1" gridHeight="1" mergedFields=""> <field id="0" alias="DV_DOOR" glasstype="glass" dindirection="left" direction="inside"/> </fields>; SystemID: 200; Version number: 1.0; Données - Thermal insulation standard: Highly thermally insulated; Opening type: Double-leaf, Inward-opening, Flush-fitted; Air permeability: Class 2; Burglar resistance: Class RC 2; Mechanical loading: Class 3; Sound insulation: to Rw ... dB; Thermal insulation: Uf to ... W/(m²K); Watertightness: Up to class 5A; Wind load resistance: Up to class C3; Long term functionality: Class 5; Façade insert unit: no; Areas of use: ...; Material: Aluminium; Glazing data: ...; __NOTE__: Data describes the optimum values of the entire system. The properites of a selected design option have to be determined on an individual basis!; Général - Edition number: 1; Matériaux et finitions - Frame: Alu
51_2V_PV_MV_XX_XX | Type 1 | 51_2V_PV_MV_XX_XX | N0 | CurrentWithCentral | NotOwned | foret-f | 412757 | Portes | B02_ARC | Autre - Famille et type: Type 1; Famille: Type 1; Type: Type 1; ID du type: Type 1; Position in wall: 0.034 m; Floor build up: 0.15 m; Gap to shell construction left: 0.01 m; Gap to shell construction right: 0.01 m; Gap to shell construction lintel: 0.01 m; Reveal left: 0.02 m; Reveal right: 0.02 m; Reveal lintel: 0.02 m; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Cotes - Surface: 5.98109 m2; Volume: 0.121198 m3; UP: 1; Largeur brute: 1.5 m; Hauteur brute: 2.25 m; Largeur: 1.5 m; Hauteur: 2.25 m; Outer frame height: 2.24 m; Outer frame width: 1.48 m; Clear opening width: 1.342 m; Type de Revit - Id: 411318; Nom: Type 1; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : 51_2V_PV_MV_XX_XX; Nom de la famille: 51_2V_PV_MV_XX_XX; Nom du type: Type 1; Note d'identification: 50_PORTE EXTERIEUR; Epaisseur: 0.06 m; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Identifiant du type: 28; Fermeture du mur: 0; Titre OmniClass: Doors; Numéro OmniClass: 23.30.10.00; Modèle: Schueco ADS 60; Fabricant: Schueco International KG; URL: www.schueco.com; Description: Schueco Aluminium Door System (ADS); Description de l'assemblage: Exterior Glazed Doors - Aluminum; Code d'assemblage: B2030110; SCal_Data: <?xml version="1.0" encoding="utf-8"?> <fields system="window" gridWidth="1" gridHeight="1" mergedFields=""> <field id="0" alias="DV_DOOR" glasstype="glass" dindirection="left" direction="inside"/> </fields>; SystemID: 200; Handle height: 1.05 m; Version number: 1.0; Thermal insulation standard: Highly thermally insulated; Edition number: 1; Opening type: Double-leaf, Inward-opening, Flush-fitted; Air permeability: Class 2; Burglar resistance: Class RC 2; Mechanical loading: Class 3; Sound insulation: to Rw ... dB; Thermal insulation: Uf to ... W/(m²K); Watertightness: Up to class 5A; Wind load resistance: Up to class C3; Long term functionality: Class 5; Façade insert unit: no; Family creation date: 04.2018; Frame: Alu; Areas of use: ...; Active leaf width: 1.1 m; Material: Aluminium; Glazing data: ...; Handles: yes; Outer frame extension left: 0 m; Outer frame extension lintel: 0 m; Outer frame extension right: 0 m; Product data url: https://www.bimobject.com/schueco/product/schueco_ads_60_inward_opening; __NOTE__: Data describes the optimum values of the entire system. The properites of a selected design option have to be determined on an individual basis!; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0; Décalage par rapport à l'hôte: -9.98742e-13 m; Elévation par défaut: 1.2192 m; Plan de construction: Niveau : N0; Niveau de nomenclature: N0; Données d'identification - Identifiant: 29; Graphismes - Leaf opening angle: 0 deg; Modèle analytique - RevT: 2.23 m; RevR: 1.48 m; RevL: 1.48 m; GapT: 2.24 m; GapR: 1.49 m; GapL: 1.49 m; F1_W: 1.1 m; F2_W: 0.38 m; InFrH: 2.24 m; InFrW: 1.48 m; Ins_Ex: 0 m; Ins_In: 0.034 m; Données - Glazing area: 2.0029 m2
51_2V_PV_MV_XX_XX | Instance | 51_2V_PV_MV_XX_XX | N0 | CurrentWithCentral | NotOwned | foret-f | 413034 | Portes | Famille : Portes : 51_2V_PV_MV_XX_XX | Cotes - Epaisseur: 0.06 m; Active leaf width: 1.1 m; Autre - Nom de la famille: 51_2V_PV_MV_XX_XX; Handle height: 1.05 m; Outer frame extension left: 0 m; Outer frame extension lintel: 0 m; Outer frame extension right: 0 m; Données d'identification - Nom du type: Type 1; Note d'identification: 50_PORTE EXTERIEUR; Titre OmniClass: Doors; Numéro OmniClass: 23.30.10.00; Modèle: Schueco ADS 60; Fabricant: Schueco International KG; URL: www.schueco.com; Description: Schueco Aluminium Door System (ADS); Description de l'assemblage: Exterior Glazed Doors - Aluminum; Code d'assemblage: B2030110; Family creation date: 04.2018; Product data url: https://www.bimobject.com/schueco/product/schueco_ads_60_inward_opening; Paramètres IFC - Exporter le type au format IFC: 0; Propriétés analytiques - Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Construction - Fermeture du mur: 0; Handles: yes; Modèle analytique - SCal_Data: <?xml version="1.0" encoding="utf-8"?> <fields system="window" gridWidth="1" gridHeight="1" mergedFields=""> <field id="0" alias="DV_DOOR" glasstype="glass" dindirection="left" direction="inside"/> </fields>; SystemID: 200; Version number: 1.0; Données - Thermal insulation standard: Highly thermally insulated; Opening type: Double-leaf, Inward-opening, Flush-fitted; Air permeability: Class 2; Burglar resistance: Class RC 2; Mechanical loading: Class 3; Sound insulation: to Rw ... dB; Thermal insulation: Uf to ... W/(m²K); Watertightness: Up to class 5A; Wind load resistance: Up to class C3; Long term functionality: Class 5; Façade insert unit: no; Areas of use: ...; Material: Aluminium; Glazing data: ...; __NOTE__: Data describes the optimum values of the entire system. The properites of a selected design option have to be determined on an individual basis!; Général - Edition number: 1; Matériaux et finitions - Frame: Alu
51_1V_PV_MM_XX_XX | Family | 51_1V_PV_MM_XX_XX | N0
51_1V_PV_MM_XX_XX | Type 1 | 51_1V_PV_MM_XX_XX | N0 | CurrentWithCentral | NotOwned | foret-f | 419574 | Portes | B02_ARC | Autre - Famille et type: Type 1; Famille: Type 1; Type: Type 1; ID du type: Type 1; Position in wall: 0.034 m; Floor build up: 0.15 m; Gap to shell construction left: 0.01 m; Gap to shell construction right: 0.01 m; Gap to shell construction lintel: 0.01 m; Reveal left: 0.02 m; Reveal right: 0.02 m; Reveal lintel: 0.02 m; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 4.88755 m2; Volume: 0.0993986 m3; UP: 1; Largeur brute: 1.32804 m; Hauteur brute: 2.25 m; Largeur: 1.32804 m; Hauteur: 2.25 m; Outer frame height: 2.24 m; Outer frame width: 1.30804 m; Clear opening width: 1.17004 m; Type de Revit - Id: 419548; Nom: Type 1; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : 51_1V_PV_MM_XX_XX; Nom de la famille: 51_1V_PV_MM_XX_XX; Nom du type: Type 1; Note d'identification: 50_PORTE EXTERIEUR; Epaisseur: 0.06 m; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Identifiant du type: 29; Fermeture du mur: 0; Titre OmniClass: Doors; Numéro OmniClass: 23.30.10.00; Modèle: Schueco ADS 60; Fabricant: Schueco International KG; URL: www.schueco.com; Description: Schueco Aluminium Door System (ADS); Description de l'assemblage: Exterior Glazed Doors - Aluminum; Code d'assemblage: B2030110; SCal_Data: <?xml version="1.0" encoding="utf-8"?> <fields system="window" gridWidth="1" gridHeight="1" mergedFields=""> <field id="0" alias="DOOR" glasstype="glass" dindirection="left" direction="inside"/> </fields>; SystemID: 200; Handle height: 1.05 m; Version number: 1.0; Thermal insulation standard: Highly thermally insulated; Edition number: 1; Opening type: Single-leaf, Inward-opening, Flush-fitted; Air permeability: Class 2; Burglar resistance: Class RC 2; Mechanical loading: Class 3; Sound insulation: to Rw ... dB; Thermal insulation: Uf to ... W/(m²K); Watertightness: Up to class 5A; Wind load resistance: Up to class C3; Long term functionality: Class 5; Façade insert unit: no; Family creation date: 04.2018; Frame: Alu; Areas of use: ...; Material: Aluminium; Glazing data: ...; Handles: yes; Outer frame extension left: 0 m; Outer frame extension lintel: 0 m; Outer frame extension right: 0 m; Product data url: https://www.bimobject.com/schueco/product/schueco_ads_60_inward_opening; __NOTE__: Data describes the optimum values of the entire system. The properites of a selected design option have to be determined on an individual basis!; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Contraintes - Niveau: N0; Décalage par rapport à l'hôte: 1.42006e-12 m; Elévation par défaut: 1.2192 m; Plan de construction: Niveau : N0; Niveau de nomenclature: N0; Données d'identification - Identifiant: 30; Graphismes - Leaf opening angle: 0 deg; Modèle analytique - RevT: 2.23 m; RevR: 1.30804 m; RevL: 1.30804 m; GapT: 2.24 m; GapR: 1.31804 m; GapL: 1.31804 m; F1_W: 1.30804 m; InFrH: 2.24 m; InFrW: 1.30804 m; Ins_Ex: 0 m; Ins_In: 0.034 m; Données - Glazing area: 2.0149 m2
51_1V_PV_MM_XX_XX | Instance | 51_1V_PV_MM_XX_XX | N0 | CurrentWithCentral | NotOwned | foret-f | 419808 | Portes | Famille : Portes : 51_1V_PV_MM_XX_XX | Cotes - Epaisseur: 0.06 m; Autre - Nom de la famille: 51_1V_PV_MM_XX_XX; Handle height: 1.05 m; Outer frame extension left: 0 m; Outer frame extension lintel: 0 m; Outer frame extension right: 0 m; Données d'identification - Nom du type: Type 1; Note d'identification: 50_PORTE EXTERIEUR; Titre OmniClass: Doors; Numéro OmniClass: 23.30.10.00; Modèle: Schueco ADS 60; Fabricant: Schueco International KG; URL: www.schueco.com; Description: Schueco Aluminium Door System (ADS); Description de l'assemblage: Exterior Glazed Doors - Aluminum; Code d'assemblage: B2030110; Family creation date: 04.2018; Product data url: https://www.bimobject.com/schueco/product/schueco_ads_60_inward_opening; Paramètres IFC - Exporter le type au format IFC: 0; Propriétés analytiques - Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Construction - Fermeture du mur: 0; Handles: yes; Modèle analytique - SCal_Data: <?xml version="1.0" encoding="utf-8"?> <fields system="window" gridWidth="1" gridHeight="1" mergedFields=""> <field id="0" alias="DOOR" glasstype="glass" dindirection="left" direction="inside"/> </fields>; SystemID: 200; Version number: 1.0; Données - Thermal insulation standard: Highly thermally insulated; Opening type: Single-leaf, Inward-opening, Flush-fitted; Air permeability: Class 2; Burglar resistance: Class RC 2; Mechanical loading: Class 3; Sound insulation: to Rw ... dB; Thermal insulation: Uf to ... W/(m²K); Watertightness: Up to class 5A; Wind load resistance: Up to class C3; Long term functionality: Class 5; Façade insert unit: no; Areas of use: ...; Material: Aluminium; Glazing data: ...; __NOTE__: Data describes the optimum values of the entire system. The properites of a selected design option have to be determined on an individual basis!; Général - Edition number: 1; Matériaux et finitions - Frame: Alu
53_TRAPPE DE VISITE | Family | 53_TRAPPE DE VISITE | N0 | ROP_SUIVIE DE CHANTIER - Installation ?: no
400x400 | Type | 400x400 | N0
53_TRAPPE DE VISITE | 400x400 | 53_TRAPPE DE VISITE | N0 | CurrentWithCentral | NotOwned | foret-f | 444213 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 400x400; Famille: 400x400; Type: 400x400; ID du type: 400x400; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: TRAPDOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 0.677437 m2; Volume: 0.0121187 m3; EPAI: 0.098 m; Type de Revit - Id: 444114; Nom: 400x400; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : 53_TRAPPE DE VISITE; Nom de la famille: 53_TRAPPE DE VISITE; Nom du type: 400x400; Note d'identification: 53_PORTE TRAPPES DE VISITE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Identifiant du type: 30; Elévation par défaut: 0.3 m; L_1: 0.4 m; H_1: 0.4 m; C_1: 0.04 m; C_2: 0.01 m; C_3: 0.013 m; CADRE: MEDIUIM MONOBLOC; PORTILLON: MEDIUM 40 mm; FINITION_COULEUE: _ Laqué blanc; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: --; GEM_ROP_REPERE CCTP: I; GEM_SEC_DEGRE COUPE FEU: EI60; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Élévation par rapport au niveau: 0.3 m; Niveau de nomenclature: N0; Données d'identification - Identifiant: 31; Construction - FERMETURE: yes
3 x 53_TRAPPE DE VISITE | Instance | 53_TRAPPE DE VISITE | N0 | CurrentWithCentral | NotOwned | foret-f | 444114 | Portes | Famille : Portes : 53_TRAPPE DE VISITE | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Nom de la famille: 53_TRAPPE DE VISITE; C_1: 0.04 m; C_2: 0.01 m; C_3: 0.013 m; Données d'identification - Nom du type: 400x400; Note d'identification: 53_PORTE TRAPPES DE VISITE; Identifiant du type: 30; Paramètres IFC - Exporter le type au format IFC: 0; Propriétés analytiques - Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Contraintes - Elévation par défaut: 0.3 m; Cotes - L_1: 0.4 m; H_1: 0.4 m; Matériaux et finitions - CADRE: MEDIUIM MONOBLOC; PORTILLON: MEDIUM 40 mm; FINITION_COULEUE: _ Laqué blanc
53_TRAPPE DE VISITE | 400x400 | 53_TRAPPE DE VISITE | N0 | CurrentWithCentral | NotOwned | foret-f | 444335 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 400x400; Famille: 400x400; Type: 400x400; ID du type: 400x400; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: TRAPDOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 0.677437 m2; Volume: 0.0121187 m3; EPAI: 0.098 m; Type de Revit - Id: 444114; Nom: 400x400; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : 53_TRAPPE DE VISITE; Nom de la famille: 53_TRAPPE DE VISITE; Nom du type: 400x400; Note d'identification: 53_PORTE TRAPPES DE VISITE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Identifiant du type: 30; Elévation par défaut: 0.3 m; L_1: 0.4 m; H_1: 0.4 m; C_1: 0.04 m; C_2: 0.01 m; C_3: 0.013 m; CADRE: MEDIUIM MONOBLOC; PORTILLON: MEDIUM 40 mm; FINITION_COULEUE: _ Laqué blanc; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: --; GEM_ROP_REPERE CCTP: I; GEM_SEC_DEGRE COUPE FEU: EI60; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Élévation par rapport au niveau: 0.3 m; Niveau de nomenclature: N0; Données d'identification - Identifiant: 32; Construction - FERMETURE: yes
53_TRAPPE DE VISITE | 400x400 | 53_TRAPPE DE VISITE | N0 | CurrentWithCentral | NotOwned | foret-f | 444784 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 400x400; Famille: 400x400; Type: 400x400; ID du type: 400x400; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: TRAPDOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 0.677437 m2; Volume: 0.0121187 m3; EPAI: 0.098 m; Type de Revit - Id: 444114; Nom: 400x400; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : 53_TRAPPE DE VISITE; Nom de la famille: 53_TRAPPE DE VISITE; Nom du type: 400x400; Note d'identification: 53_PORTE TRAPPES DE VISITE; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Identifiant du type: 30; Elévation par défaut: 0.3 m; L_1: 0.4 m; H_1: 0.4 m; C_1: 0.04 m; C_2: 0.01 m; C_3: 0.013 m; CADRE: MEDIUIM MONOBLOC; PORTILLON: MEDIUM 40 mm; FINITION_COULEUE: _ Laqué blanc; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: --; GEM_ROP_REPERE CCTP: I; GEM_SEC_DEGRE COUPE FEU: EI60; Contraintes - Niveau: N0; Hôte: Mur de base : 23_CLS_152/100_PAREMENT_2BA13_EI60_41db; Élévation par rapport au niveau: 0.3 m; Niveau de nomenclature: N0; Données d'identification - Identifiant: 33; Construction - FERMETURE: yes
PRT_SIMPLE_HUI_58x68x48 TUNE L | Family | PRT_SIMPLE_HUI_58x68x48 TUNE L | N0 | ROP_SUIVIE DE CHANTIER - Installation ?: no
PRT_BOIS_1V_EI30_930x2040x40 | Type | PRT_BOIS_1V_EI30_930x2040x40 | N0
PRT_SIMPLE_HUI_58x68x48 TUNE L | PRT_BOIS_1V_EI30_930x2040x40 | PRT_SIMPLE_HUI_58x68x48 TUNE L | N0 | CurrentWithCentral | NotOwned | foret-f | 464752 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: PRT_BOIS_1V_EI30_930x2040x40; Famille: PRT_BOIS_1V_EI30_930x2040x40; Type: PRT_BOIS_1V_EI30_930x2040x40; ID du type: PRT_BOIS_1V_EI30_930x2040x40; wwwww: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 2.18516 m2; Volume: 0.076475 m3; POIGNEE_DC_PR: 0.0485 m; HAUTEUR LIBRE: 2.0345 m; PASSAGE LIBRE: 0.864002 m; UP: 1; Type de Revit - Id: 552185; Nom: PRT_BOIS_1V_EI30_930x2040x40; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : PRT_SIMPLE_HUI_58x68x48 TUNE L; Nom de la famille: PRT_SIMPLE_HUI_58x68x48 TUNE L; Nom du type: PRT_BOIS_1V_EI30_930x2040x40; Note d'identification: 51_PORTE INTERIEUR; Largeur: 0.93 m; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Identifiant du type: 36; Fermeture du mur: 0; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Hauteur: 2.047 m; Opération: SingleSwingLeft; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; CLASSEMENT AU FEU: Ame pleine; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.3.2; GEM_ROP_REPERE CCTP: G; GEM_SEC_DEGRE COUPE FEU: EI30; Contraintes - Niveau: N0; Décalage par rapport à l'hôte: 0 m; Elévation par défaut: 1.2192 m; Plan de construction: <non associé>; Niveau de nomenclature: N0; Données d'identification - Identifiant: 34; Graphismes - Angle d'ouverture 3D: 0 deg; Angle d'ouverture 2D fixe: yes
2 x PRT_SIMPLE_HUI_58x68x48 TUNE L | Instance | PRT_SIMPLE_HUI_58x68x48 TUNE L | N0 | CurrentWithCentral | NotOwned | foret-f | 552185 | Portes | Famille : Portes : PRT_SIMPLE_HUI_58x68x48 TUNE L | Cotes - Epaisseur: 0.04 m; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Largeur: 0.93 m; Hauteur: 2.047 m; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; Autre - Nom de la famille: PRT_SIMPLE_HUI_58x68x48 TUNE L; Données d'identification - Nom du type: PRT_BOIS_1V_EI30_930x2040x40; Note d'identification: 51_PORTE INTERIEUR; Identifiant du type: 36; Paramètres IFC - Exporter le type au format IFC: 0; Opération: SingleSwingLeft; Propriétés analytiques - Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Construction - Fermeture du mur: 0; Données - PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; Protection contre les incendies - CLASSEMENT AU FEU: Ame pleine
PRT_SIMPLE_HUI_58x68x48 TUNE L | PRT_BOIS_1V_EI30_930x2040x40 | PRT_SIMPLE_HUI_58x68x48 TUNE L | N0 | CurrentWithCentral | NotOwned | foret-f | 476167 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: PRT_BOIS_1V_EI30_930x2040x40; Famille: PRT_BOIS_1V_EI30_930x2040x40; Type: PRT_BOIS_1V_EI30_930x2040x40; ID du type: PRT_BOIS_1V_EI30_930x2040x40; wwwww: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 2.18516 m2; Volume: 0.076475 m3; POIGNEE_DC_PR: 0.0485 m; HAUTEUR LIBRE: 2.0345 m; PASSAGE LIBRE: 0.864002 m; UP: 1; Type de Revit - Id: 552185; Nom: PRT_BOIS_1V_EI30_930x2040x40; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : PRT_SIMPLE_HUI_58x68x48 TUNE L; Nom de la famille: PRT_SIMPLE_HUI_58x68x48 TUNE L; Nom du type: PRT_BOIS_1V_EI30_930x2040x40; Note d'identification: 51_PORTE INTERIEUR; Largeur: 0.93 m; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Identifiant du type: 36; Fermeture du mur: 0; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Hauteur: 2.047 m; Opération: SingleSwingLeft; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; CLASSEMENT AU FEU: Ame pleine; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.3.2; GEM_ROP_REPERE CCTP: G; GEM_SEC_DEGRE COUPE FEU: EI30; Contraintes - Niveau: N0; Décalage par rapport à l'hôte: 0 m; Elévation par défaut: 1.2192 m; Plan de construction: Sol : 44_SOL TYPE A; Niveau de nomenclature: N0; Données d'identification - Identifiant: 35; Graphismes - Angle d'ouverture 3D: 0 deg; Angle d'ouverture 2D fixe: yes
51_PORTE_2 VENTEAUX TUNEL | Family | 51_PORTE_2 VENTEAUX TUNEL | N0
166X204 | Type | 166X204 | N0
51_PORTE_2 VENTEAUX TUNEL | 166X204 | 51_PORTE_2 VENTEAUX TUNEL | N0 | CurrentWithCentral | NotOwned | foret-f | 476223 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 166X204; Famille: 166X204; Type: 166X204; ID du type: 166X204; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 4.94971 m2; Volume: 0.179203 m3; UP: 2; ANGLE_Ouverture: 0 deg; Type de Revit - Id: 464613; Nom: 166X204; Catégorie: Portes; Exporter le type au format IFC: 1; Sous-projet: Famille : Portes : 51_PORTE_2 VENTEAUX TUNEL; Nom de la famille: 51_PORTE_2 VENTEAUX TUNEL; Nom du type: 166X204; Note d'identification: 51_PORTE INTERIEUR; Largeur: 1.66 m; Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Identifiant du type: 35; Fermeture du mur: 0; Hauteur: 2.04 m; Titre OmniClass: Doors; Numéro OmniClass: 23.30.10.00; Exporter le type au format IFC sous: IfcDoorType; Type: Type prédéfini d'IFC: DOOR; Largeur du cadre: 0.075 m; TALON: 0.015 m; EPAI_DORMANT: 0.046 m; L_Panneau: 0.845 m; H_Panneau: 2.055 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.3.3; GEM_ROP_REPERE CCTP: H; GEM_SEC_DEGRE COUPE FEU: EI60; Contraintes - Niveau: N0; Décalage par rapport à l'hôte: -0.015 m; Elévation par défaut: 1.2192 m; Plan de construction: <non associé>; Niveau de nomenclature: N0; Données d'identification - Identifiant: 36; Visibilité - symbolique 90: yes; symbolique 30: no
51_PORTE_2 VENTEAUX TUNEL | Instance | 51_PORTE_2 VENTEAUX TUNEL | N0 | CurrentWithCentral | NotOwned | foret-f | 479372 | Portes | Famille : Portes : 51_PORTE_2 VENTEAUX TUNEL | Autre - Nom de la famille: 51_PORTE_2 VENTEAUX TUNEL; Largeur du cadre: 0.075 m; L_Panneau: 0.845 m; H_Panneau: 2.055 m; Données d'identification - Nom du type: 166X204; Titre OmniClass: Doors; Numéro OmniClass: 23.30.10.00; Cotes - Largeur: 1.66 m; Hauteur: 2.04 m; TALON: 0.015 m; EPAI_DORMANT: 0.046 m; Paramètres IFC - Exporter le type au format IFC: 0; Propriétés analytiques - Définir les propriétés thermiques par: 1; Construction analytique: <Aucun>; Construction - Fermeture du mur: 0
Murs | Category | Murs | N0
Mur de base | Family | Mur de base | N0
14_ISOLATION TT VERTICAL | Type | 14_ISOLATION TT VERTICAL | N0
Mur de base | 14_ISOLATION TT VERTICAL | Mur de base | N0 | CurrentWithCentral | NotOwned | foret-f | 428268 | Murs | B02_ARC | Autre - Famille et type: 14_ISOLATION TT VERTICAL; Famille: 14_ISOLATION TT VERTICAL; Type: 14_ISOLATION TT VERTICAL; ID du type: 14_ISOLATION TT VERTICAL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 3.08005 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0; Hauteur non contrainte: 0.392 m; Limite de pièce: yes; Cotes - Surface: 2.09191 m2; Volume: 0.209183 m3; Longueur: 5.33683 m; Reste concentrique: yes; Type de Revit - Id: 427402; Nom: 14_ISOLATION TT VERTICAL; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 14_ISOLATION TT VERTICAL; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Commentaires du type: Extérieur voile BA 20; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 1; Retournement aux extrémités: 1; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Graphismes - Marque centrale visible: no
Mur de base | 14_ISOLATION TT VERTICAL | Mur de base | N0 | CurrentWithCentral | NotOwned | foret-f | 428273 | Murs | B02_ARC | Autre - Famille et type: 14_ISOLATION TT VERTICAL; Famille: 14_ISOLATION TT VERTICAL; Type: 14_ISOLATION TT VERTICAL; ID du type: 14_ISOLATION TT VERTICAL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 3.08005 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0; Hauteur non contrainte: 0.392 m; Limite de pièce: yes; Cotes - Surface: 3.31264 m2; Volume: 0.331112 m3; Longueur: 8.44673 m; Reste concentrique: yes; Type de Revit - Id: 427402; Nom: 14_ISOLATION TT VERTICAL; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 14_ISOLATION TT VERTICAL; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Commentaires du type: Extérieur voile BA 20; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 1; Retournement aux extrémités: 1; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Graphismes - Marque centrale visible: no
Mur de base | 14_ISOLATION TT VERTICAL | Mur de base | N0 | CurrentWithCentral | NotOwned | foret-f | 428278 | Murs | B02_ARC | Autre - Famille et type: 14_ISOLATION TT VERTICAL; Famille: 14_ISOLATION TT VERTICAL; Type: 14_ISOLATION TT VERTICAL; ID du type: 14_ISOLATION TT VERTICAL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 3.08005 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0; Hauteur non contrainte: 0.392 m; Limite de pièce: yes; Cotes - Surface: 1.3565 m2; Volume: 0.135557 m3; Longueur: 3.5081 m; Reste concentrique: yes; Type de Revit - Id: 427402; Nom: 14_ISOLATION TT VERTICAL; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 14_ISOLATION TT VERTICAL; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Commentaires du type: Extérieur voile BA 20; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 1; Retournement aux extrémités: 1; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Graphismes - Marque centrale visible: no
Mur de base | 14_ISOLATION TT VERTICAL | Mur de base | N0 | CurrentWithCentral | NotOwned | foret-f | 428284 | Murs | B02_ARC | Autre - Famille et type: 14_ISOLATION TT VERTICAL; Famille: 14_ISOLATION TT VERTICAL; Type: 14_ISOLATION TT VERTICAL; ID du type: 14_ISOLATION TT VERTICAL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 3.08005 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0; Hauteur non contrainte: 0.392 m; Limite de pièce: yes; Cotes - Surface: 0.724361 m2; Volume: 0.0724238 m3; Longueur: 1.89755 m; Type de Revit - Id: 427402; Nom: 14_ISOLATION TT VERTICAL; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 14_ISOLATION TT VERTICAL; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Commentaires du type: Extérieur voile BA 20; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 1; Retournement aux extrémités: 1; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0
Mur de base | 14_ISOLATION TT VERTICAL | Mur de base | N0 | CurrentWithCentral | NotOwned | foret-f | 428298 | Murs | B02_ARC | Autre - Famille et type: 14_ISOLATION TT VERTICAL; Famille: 14_ISOLATION TT VERTICAL; Type: 14_ISOLATION TT VERTICAL; ID du type: 14_ISOLATION TT VERTICAL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 3.08005 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0; Hauteur non contrainte: 0.630961 m; Limite de pièce: yes; Cotes - Surface: 1.72335 m2; Volume: 0.169333 m3; Longueur: 2.68238 m; Type de Revit - Id: 427402; Nom: 14_ISOLATION TT VERTICAL; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 14_ISOLATION TT VERTICAL; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Commentaires du type: Extérieur voile BA 20; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 1; Retournement aux extrémités: 1; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0
Mur de base | 14_ISOLATION TT VERTICAL | Mur de base | N0 | CurrentWithCentral | NotOwned | foret-f | 428780 | Murs | B02_ARC | Autre - Famille et type: 14_ISOLATION TT VERTICAL; Famille: 14_ISOLATION TT VERTICAL; Type: 14_ISOLATION TT VERTICAL; ID du type: 14_ISOLATION TT VERTICAL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 3.08005 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0; Hauteur non contrainte: 0.392 m; Limite de pièce: yes; Cotes - Surface: 0.126073 m2; Volume: 0.0126054 m3; Longueur: 0.276412 m; Type de Revit - Id: 427402; Nom: 14_ISOLATION TT VERTICAL; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 14_ISOLATION TT VERTICAL; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Commentaires du type: Extérieur voile BA 20; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 1; Retournement aux extrémités: 1; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0
Mur de base | 14_ISOLATION TT VERTICAL | Mur de base | N0 | CurrentWithCentral | NotOwned | foret-f | 428890 | Murs | B02_ARC | Autre - Famille et type: 14_ISOLATION TT VERTICAL; Famille: 14_ISOLATION TT VERTICAL; Type: 14_ISOLATION TT VERTICAL; ID du type: 14_ISOLATION TT VERTICAL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 3.08005 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0; Hauteur non contrainte: 0.392 m; Limite de pièce: yes; Cotes - Surface: 0.886032 m2; Volume: 0.0885657 m3; Longueur: 2.25933 m; Reste concentrique: yes; Type de Revit - Id: 427402; Nom: 14_ISOLATION TT VERTICAL; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 14_ISOLATION TT VERTICAL; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Commentaires du type: Extérieur voile BA 20; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 1; Retournement aux extrémités: 1; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Graphismes - Marque centrale visible: no
Mur de base | 14_ISOLATION TT VERTICAL | Mur de base | N0 | CurrentWithCentral | NotOwned | foret-f | 428997 | Murs | B02_ARC | Autre - Famille et type: 14_ISOLATION TT VERTICAL; Famille: 14_ISOLATION TT VERTICAL; Type: 14_ISOLATION TT VERTICAL; ID du type: 14_ISOLATION TT VERTICAL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 3.08005 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0; Hauteur non contrainte: 0.750961 m; Limite de pièce: yes; Cotes - Surface: 4.22412 m2; Volume: 0.422379 m3; Longueur: 6.43855 m; Type de Revit - Id: 427402; Nom: 14_ISOLATION TT VERTICAL; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 14_ISOLATION TT VERTICAL; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Commentaires du type: Extérieur voile BA 20; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 1; Retournement aux extrémités: 1; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0
Mur de base | 14_ISOLATION TT VERTICAL | Mur de base | N0 | CurrentWithCentral | NotOwned | foret-f | 429085 | Murs | B02_ARC | Autre - Famille et type: 14_ISOLATION TT VERTICAL; Famille: 14_ISOLATION TT VERTICAL; Type: 14_ISOLATION TT VERTICAL; ID du type: 14_ISOLATION TT VERTICAL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 3.47205 m; Extension inférieure: 0 m; Extension supérieure: 0.12 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0; Hauteur non contrainte: 0.238961 m; Limite de pièce: yes; Cotes - Surface: 1.48996 m2; Volume: 0.148993 m3; Longueur: 6.28503 m; Type de Revit - Id: 427402; Nom: 14_ISOLATION TT VERTICAL; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 14_ISOLATION TT VERTICAL; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Commentaires du type: Extérieur voile BA 20; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 1; Retournement aux extrémités: 1; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0
Mur de base | 14_ISOLATION TT VERTICAL | Mur de base | N0 | CurrentWithCentral | NotOwned | foret-f | 429089 | Murs | B02_ARC | Autre - Famille et type: 14_ISOLATION TT VERTICAL; Famille: 14_ISOLATION TT VERTICAL; Type: 14_ISOLATION TT VERTICAL; ID du type: 14_ISOLATION TT VERTICAL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 3.47205 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0; Hauteur non contrainte: 0.358961 m; Limite de pièce: yes; Cotes - Surface: 1.5996 m2; Volume: 0.159905 m3; Longueur: 6.11683 m; Reste concentrique: yes; Type de Revit - Id: 427402; Nom: 14_ISOLATION TT VERTICAL; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 14_ISOLATION TT VERTICAL; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Commentaires du type: Extérieur voile BA 20; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 1; Retournement aux extrémités: 1; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Graphismes - Marque centrale visible: no
Mur de base | 14_ISOLATION TT VERTICAL | Mur de base | N0 | CurrentWithCentral | NotOwned | foret-f | 429094 | Murs | B02_ARC | Autre - Famille et type: 14_ISOLATION TT VERTICAL; Famille: 14_ISOLATION TT VERTICAL; Type: 14_ISOLATION TT VERTICAL; ID du type: 14_ISOLATION TT VERTICAL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 3.47205 m; Extension inférieure: 0 m; Extension supérieure: 0.12 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0; Hauteur non contrainte: 0.238961 m; Limite de pièce: yes; Cotes - Surface: 1.59919 m2; Volume: 0.159907 m3; Longueur: 6.74178 m; Type de Revit - Id: 427402; Nom: 14_ISOLATION TT VERTICAL; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 14_ISOLATION TT VERTICAL; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Commentaires du type: Extérieur voile BA 20; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 1; Retournement aux extrémités: 1; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0
Mur de base | 14_ISOLATION TT VERTICAL | Mur de base | N0 | CurrentWithCentral | NotOwned | foret-f | 429232 | Murs | B02_ARC | Autre - Famille et type: 14_ISOLATION TT VERTICAL; Famille: 14_ISOLATION TT VERTICAL; Type: 14_ISOLATION TT VERTICAL; ID du type: 14_ISOLATION TT VERTICAL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 3.47205 m; Extension inférieure: 0 m; Extension supérieure: 0.1 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0; Hauteur non contrainte: 0.238961 m; Limite de pièce: yes; Cotes - Surface: 1.54158 m2; Volume: 0.154132 m3; Longueur: 6.40008 m; Type de Revit - Id: 427402; Nom: 14_ISOLATION TT VERTICAL; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 14_ISOLATION TT VERTICAL; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Commentaires du type: Extérieur voile BA 20; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 1; Retournement aux extrémités: 1; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0
Mur de base | 14_ISOLATION TT VERTICAL | Mur de base | N0 | CurrentWithCentral | NotOwned | foret-f | 429236 | Murs | B02_ARC | Autre - Famille et type: 14_ISOLATION TT VERTICAL; Famille: 14_ISOLATION TT VERTICAL; Type: 14_ISOLATION TT VERTICAL; ID du type: 14_ISOLATION TT VERTICAL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 3.47205 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0; Hauteur non contrainte: 0.238961 m; Limite de pièce: yes; Cotes - Surface: 0.530852 m2; Volume: 0.0530592 m3; Longueur: 2.27043 m; Type de Revit - Id: 427402; Nom: 14_ISOLATION TT VERTICAL; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 14_ISOLATION TT VERTICAL; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Commentaires du type: Extérieur voile BA 20; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 1; Retournement aux extrémités: 1; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0
Mur de base | 14_ISOLATION TT VERTICAL | Mur de base | N0 | CurrentWithCentral | NotOwned | foret-f | 429240 | Murs | B02_ARC | Autre - Famille et type: 14_ISOLATION TT VERTICAL; Famille: 14_ISOLATION TT VERTICAL; Type: 14_ISOLATION TT VERTICAL; ID du type: 14_ISOLATION TT VERTICAL; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 3.47205 m; Extension inférieure: 0 m; Extension supérieure: 0.1 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0; Hauteur non contrainte: 0.238961 m; Limite de pièce: yes; Cotes - Surface: 1.62005 m2; Volume: 0.161979 m3; Longueur: 6.8285 m; Type de Revit - Id: 427402; Nom: 14_ISOLATION TT VERTICAL; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 14_ISOLATION TT VERTICAL; Note d'identification: 28_TOIT ,COMPRIS LES TOIT PLATS; Commentaires du type: Extérieur voile BA 20; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 1; Retournement aux extrémités: 1; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.1 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0
23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | Type | 23_DOU_160_MONOPAREMENT_1BA25_IE30_XXdb | N0
43-PAR_BA13 | Type | 43-PAR_BA13 | N0
Générique - Ext. 150 mm | Type | Générique - Ext. 150 mm | N0
Mur de base | Générique - Ext. 150 mm | Mur de base | N0 | CurrentWithCentral | NotOwned | foret-f | 530204 | Murs | 2021_015 | Autre - Famille et type: Générique - Ext. 150 mm; Famille: Générique - Ext. 150 mm; Type: Générique - Ext. 150 mm; ID du type: Générique - Ext. 150 mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 2.09785 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0; Hauteur non contrainte: 0.122146 m; Limite de pièce: yes; Cotes - Surface: 0.122757 m2; Volume: 0.0184135 m3; Longueur: 1.0175 m; Type de Revit - Id: 29332; Nom: Générique - Ext. 150 mm; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: Générique - Ext. 150 mm; Matériau structurel: Mur par défaut; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 0; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.15 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS
44_PROTECTION MURALE | Type | 44_PROTECTION MURALE | N0
Solide topographique | Category | Solide topographique | N0
Solide topographique | Family | Solide topographique | N0
Solide topographiquerevegetalisation | Type | Solide topographiquerevegetalisation | N0
VOIE CIRCULATION | Type | VOIE CIRCULATION | N0
glacie | Type | glacie | N0
Garde-corps | Category | Garde-corps | N0
Garde-corps | Family | Garde-corps | N0
bordure t1 | Type | bordure t1 | N0
Garde-corps | bordure t1 | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 486505 | Garde-corps | 2021_015_RAMPE | Autre - Famille et type: bordure t1; Famille: bordure t1; Type: bordure t1; ID du type: bordure t1; Paramètres IFC - Exporter au format IFC: 0; Exporter au format IFC sous: IfcKerbType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Cotes - Longueur: 9.51783 m; Type de Revit - Id: 484848; Nom: bordure t1; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: bordure t1; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 05; GEM_ROP_NOM DU LOT: VRD
Garde-corps | Instance | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 486506 |  | 2021_015_RAMPE | Données d'identification - Nom du type: Garde-corps
Garde-corps | bordure t1 | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 488017 | Garde-corps | 2021_015_RAMPE | Autre - Famille et type: bordure t1; Famille: bordure t1; Type: bordure t1; ID du type: bordure t1; Paramètres IFC - Exporter au format IFC: 0; Exporter au format IFC sous: IfcKerbType; Revizto - Architecture: yes; Contraintes - Décalage inférieur: 0 m; Décalage à partir de la trajectoire: 0 m; Cotes - Longueur: 5.5499 m; Type de Revit - Id: 484848; Nom: bordure t1; Catégorie: Garde-corps; Exporter le type au format IFC: 0; Sous-projet: Type de garde-corps; Nom de la famille: Garde-corps; Nom du type: bordure t1; Hauteur: 0 m; Position: 0; Utiliser une traverse haute: no; Connexion des traverses: 1; Joints d'angle: 0; Joints tangents: 2; Réglage de la hauteur du palier: 0 m; Utiliser le réglage de la hauteur du palier: no; Décalage des barreaux: 0 m; Hauteur du garde-corps: 0 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 05; GEM_ROP_NOM DU LOT: VRD
Garde-corps | Instance | Garde-corps | N0 | CurrentWithCentral | NotOwned | foret-f | 488018 |  | 2021_015_RAMPE | Données d'identification - Nom du type: Garde-corps
