Properties of the parts of a building model (IFC4), part 3 of 11

# IfcBuildingElementPart (663)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 322814 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.52 m; Cotes - Surface: 24.9451 m2; Volume: 6.48571 m3; Périmètre: 21.1821 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 322857 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.52 m; Cotes - Surface: 20.4155 m2; Volume: 5.30802 m3; Périmètre: 20.1805 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 322921 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.52 m; Cotes - Surface: 20.9391 m2; Volume: 5.44418 m3; Périmètre: 18.308 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 322965 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.52 m; Cotes - Surface: 29.9185 m2; Volume: 7.77883 m3; Périmètre: 48.3812 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 323108 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.42 m; Cotes - Surface: 34.4033 m2; Volume: 8.94485 m3; Périmètre: 34.1976 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 323183 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.52 m; Cotes - Surface: 5.76715 m2; Volume: 1.49946 m3; Périmètre: 9.66963 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 323222 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.52 m; Cotes - Surface: 6.11753 m2; Volume: 1.59056 m3; Périmètre: 10.3047 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 323292 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.52 m; Cotes - Surface: 6.23069 m2; Volume: 1.61998 m3; Périmètre: 10.5747 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 323340 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.52 m; Cotes - Surface: 5.55467 m2; Volume: 1.44422 m3; Périmètre: 9.97117 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 323437 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.42 m; Cotes - Surface: 8.45278 m2; Volume: 2.19772 m3; Périmètre: 16.7883 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 323483 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.52 m; Cotes - Surface: 3.23331 m2; Volume: 0.84066 m3; Périmètre: 7.78866 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 323619 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.52 m; Cotes - Surface: 3.95497 m2; Volume: 1.02829 m3; Périmètre: 7.95591 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 342943 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.42 m; Cotes - Surface: 7.11619 m2; Volume: 1.85021 m3; Périmètre: 11.7591 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 504941 | Plafonds | 2021_015 | Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.42 m; Cotes - Surface: 1.66897 m2; Volume: 0.433933 m3; Périmètre: 5.23163 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 2; Nom: Nouvelle construction; Sous-projet: Paramètres des phases; Id: 0; Phase de construction - Phase de création: Nouvelle construction; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 505056 | Plafonds | 2021_015 | Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.52 m; Cotes - Surface: 3.22148 m2; Volume: 0.837585 m3; Périmètre: 8.35541 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
43_PAR_SOUS FACE | Type | 43_PAR_SOUS FACE | N0_FINI
Plafond composé | 43_PAR_SOUS FACE | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 341737 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43_PAR_SOUS FACE; Famille: 43_PAR_SOUS FACE; Type: 43_PAR_SOUS FACE; ID du type: 43_PAR_SOUS FACE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.0265 m; Cotes - Surface: 0.255 m2; Volume: 0.0034425 m3; Périmètre: 3.34 m; Type de Revit - Id: 341400; Nom: 43_PAR_SOUS FACE; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 43_PAR_SOUS FACE; Note d'identification: 23_CLOISON; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.0135 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: TYPE B
45_PLAFOND PLAQUE PLATRE PERFORE | Type | 45_PLAFOND PLAQUE PLATRE PERFORE | N0_FINI
Plafond composé | 45_PLAFOND PLAQUE PLATRE PERFORE | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 423074 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_PLAFOND PLAQUE PLATRE PERFORE; Famille: 45_PLAFOND PLAQUE PLATRE PERFORE; Type: 45_PLAFOND PLAQUE PLATRE PERFORE; ID du type: 45_PLAFOND PLAQUE PLATRE PERFORE; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 21.6 m2; Volume: 0.432 m3; Périmètre: 19.2 m; Type de Revit - Id: 363162; Nom: 45_PLAFOND PLAQUE PLATRE PERFORE; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_PLAFOND PLAQUE PLATRE PERFORE; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 1; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.2.3; GEM_ROP_REPERE CCTP: TYPE E
Portes | Category | Portes | N0_FINI
PRT_SIMPLE_HUI_58x68x48 | Family | PRT_SIMPLE_HUI_58x68x48 | N0_FINI
PRT_BOIS_1V_930x2040x40 | Type | PRT_BOIS_1V_930x2040x40 | N0_FINI
PRT_SIMPLE_HUI_58x68x48 | PRT_BOIS_1V_930x2040x40 | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 336587 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: PRT_BOIS_1V_930x2040x40; Famille: PRT_BOIS_1V_930x2040x40; Type: PRT_BOIS_1V_930x2040x40; ID du type: PRT_BOIS_1V_930x2040x40; ID hôte: 23_CLS_95/70_1BA13_EIXX_31db; Hauteur sous linteau: 2.037 m; wwwww: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 2.18516 m2; Volume: 0.076475 m3; POIGNEE_DC_PR: 0.0485 m; HAUTEUR LIBRE: 2.0345 m; PASSAGE LIBRE: 0.864002 m; UP: 1; Type de Revit - Id: 552220; Nom: PRT_BOIS_1V_930x2040x40; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : PRT_SIMPLE_HUI_58x68x48; Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Nom du type: PRT_BOIS_1V_930x2040x40; Fonction: 0; Largeur: 0.93 m; 01RVZ_CLASSIFICATIONS: 51_PORTES INTERIEUR; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Identifiant du type: 38; Fermeture du mur: 0; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Hauteur: 2.047 m; Opération: SingleSwingLeft; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; CLASSEMENT AU FEU: Ame pleine; NOM DU MODELE: 1V EI30 - Portaphone - HB; URL 1 (FICHE TECHNIQUE): ..\01_FICHES_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\PORTES_SIMPLES\3-MBA-051_1V EI30 - Portaphone - HB.pdf; NOM DE L'ELEMENT: PORTES_SIMPLES; NOM DU BATIMENT: BIO; ISSUE DE SECOURS: no; TYPE DE PORTE: BOIS; HUISSERIE: BOIS; MATERIAU PANNEAU: Cadre bois exo. + ame pleine; IMPOSTE: no; PAUMELLES: Universelle Inox; URL 3 (PLANS 2D): ..\02_PLANS_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\LPA-L04-PLA-TN-E-5514_Repérage LPA_PRT.pdf; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.3.1; GEM_ROP_REPERE CCTP: F; Contraintes - Niveau: N0_FINI; Hauteur de l'appui: -0.01 m; Données d'identification - Identifiant: 4; Graphismes - Angle d'ouverture 3D: 0 deg; Angle d'ouverture 2D fixe: yes; Texte - TALON: 0.01
5 x PRT_SIMPLE_HUI_58x68x48 | Instance | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 552384 | Portes | Famille : Portes : PRT_SIMPLE_HUI_58x68x48 | Cotes - Epaisseur: 0.04 m; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Largeur: 0.93 m; Hauteur: 2.047 m; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; Autre - Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Données d'identification - Nom du type: PRT_BOIS_1V_930x2040x40; Paramètres IFC - Exporter le type au format IFC: 0; Opération: SingleSwingLeft; Propriétés analytiques - Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Construction - Fermeture du mur: 0; Fonction: 0; Données - PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; Protection contre les incendies - CLASSEMENT AU FEU: Ame pleine
PRT_SIMPLE_HUI_58x68x48 | PRT_BOIS_1V_930x2040x40 | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 336626 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: PRT_BOIS_1V_930x2040x40; Famille: PRT_BOIS_1V_930x2040x40; Type: PRT_BOIS_1V_930x2040x40; ID du type: PRT_BOIS_1V_930x2040x40; ID hôte: 23_CLS_95/70_1BA13_EIXX_31db; Hauteur sous linteau: 2.037 m; wwwww: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 2.18516 m2; Volume: 0.076475 m3; POIGNEE_DC_PR: 0.0485 m; HAUTEUR LIBRE: 2.0345 m; PASSAGE LIBRE: 0.864002 m; UP: 1; Type de Revit - Id: 552220; Nom: PRT_BOIS_1V_930x2040x40; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : PRT_SIMPLE_HUI_58x68x48; Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Nom du type: PRT_BOIS_1V_930x2040x40; Fonction: 0; Largeur: 0.93 m; 01RVZ_CLASSIFICATIONS: 51_PORTES INTERIEUR; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Identifiant du type: 38; Fermeture du mur: 0; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Hauteur: 2.047 m; Opération: SingleSwingLeft; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; CLASSEMENT AU FEU: Ame pleine; NOM DU MODELE: 1V EI30 - Portaphone - HB; URL 1 (FICHE TECHNIQUE): ..\01_FICHES_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\PORTES_SIMPLES\3-MBA-051_1V EI30 - Portaphone - HB.pdf; NOM DE L'ELEMENT: PORTES_SIMPLES; NOM DU BATIMENT: BIO; ISSUE DE SECOURS: no; TYPE DE PORTE: BOIS; HUISSERIE: BOIS; MATERIAU PANNEAU: Cadre bois exo. + ame pleine; IMPOSTE: no; PAUMELLES: Universelle Inox; URL 3 (PLANS 2D): ..\02_PLANS_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\LPA-L04-PLA-TN-E-5514_Repérage LPA_PRT.pdf; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.3.1; GEM_ROP_REPERE CCTP: F; Contraintes - Niveau: N0_FINI; Hauteur de l'appui: -0.01 m; Données d'identification - Identifiant: 5; Graphismes - Angle d'ouverture 3D: 0 deg; Angle d'ouverture 2D fixe: yes; Texte - TALON: 0.01
PRT_SIMPLE_HUI_58x68x48 | Instance | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 552386 | Portes | Famille : Portes : PRT_SIMPLE_HUI_58x68x48 | Cotes - Epaisseur: 0.04 m; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Largeur: 0.93 m; Hauteur: 2.047 m; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; Autre - Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Données d'identification - Nom du type: PRT_BOIS_1V_930x2040x40; Paramètres IFC - Exporter le type au format IFC: 0; Opération: SingleSwingLeft; Propriétés analytiques - Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Construction - Fermeture du mur: 0; Fonction: 0; Données - PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; Protection contre les incendies - CLASSEMENT AU FEU: Ame pleine
PRT_SIMPLE_HUI_58x68x48 | PRT_BOIS_1V_930x2040x40 | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 336784 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: PRT_BOIS_1V_930x2040x40; Famille: PRT_BOIS_1V_930x2040x40; Type: PRT_BOIS_1V_930x2040x40; ID du type: PRT_BOIS_1V_930x2040x40; ID hôte: 23_CLS_95/70_1BA13_EIXX_31db; Hauteur sous linteau: 2.037 m; wwwww: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 2.18516 m2; Volume: 0.076475 m3; POIGNEE_DC_PR: 0.0485 m; HAUTEUR LIBRE: 2.0345 m; PASSAGE LIBRE: 0.864002 m; UP: 1; Type de Revit - Id: 552220; Nom: PRT_BOIS_1V_930x2040x40; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : PRT_SIMPLE_HUI_58x68x48; Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Nom du type: PRT_BOIS_1V_930x2040x40; Fonction: 0; Largeur: 0.93 m; 01RVZ_CLASSIFICATIONS: 51_PORTES INTERIEUR; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Identifiant du type: 38; Fermeture du mur: 0; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Hauteur: 2.047 m; Opération: SingleSwingLeft; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; CLASSEMENT AU FEU: Ame pleine; NOM DU MODELE: 1V EI30 - Portaphone - HB; URL 1 (FICHE TECHNIQUE): ..\01_FICHES_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\PORTES_SIMPLES\3-MBA-051_1V EI30 - Portaphone - HB.pdf; NOM DE L'ELEMENT: PORTES_SIMPLES; NOM DU BATIMENT: BIO; ISSUE DE SECOURS: no; TYPE DE PORTE: BOIS; HUISSERIE: BOIS; MATERIAU PANNEAU: Cadre bois exo. + ame pleine; IMPOSTE: no; PAUMELLES: Universelle Inox; URL 3 (PLANS 2D): ..\02_PLANS_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\LPA-L04-PLA-TN-E-5514_Repérage LPA_PRT.pdf; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.3.1; GEM_ROP_REPERE CCTP: F; Contraintes - Niveau: N0_FINI; Hauteur de l'appui: -0.01 m; Données d'identification - Identifiant: 7; Graphismes - Angle d'ouverture 3D: 0 deg; Angle d'ouverture 2D fixe: yes; Texte - TALON: 0.01
PRT_SIMPLE_HUI_58x68x48 | PRT_BOIS_1V_930x2040x40 | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 336840 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: PRT_BOIS_1V_930x2040x40; Famille: PRT_BOIS_1V_930x2040x40; Type: PRT_BOIS_1V_930x2040x40; ID du type: PRT_BOIS_1V_930x2040x40; ID hôte: 23_CLS_95/70_1BA13_EIXX_31db; Hauteur sous linteau: 2.037 m; wwwww: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 2.18516 m2; Volume: 0.076475 m3; POIGNEE_DC_PR: 0.0485 m; HAUTEUR LIBRE: 2.0345 m; PASSAGE LIBRE: 0.864002 m; UP: 1; Type de Revit - Id: 552220; Nom: PRT_BOIS_1V_930x2040x40; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : PRT_SIMPLE_HUI_58x68x48; Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Nom du type: PRT_BOIS_1V_930x2040x40; Fonction: 0; Largeur: 0.93 m; 01RVZ_CLASSIFICATIONS: 51_PORTES INTERIEUR; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Identifiant du type: 38; Fermeture du mur: 0; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Hauteur: 2.047 m; Opération: SingleSwingLeft; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; CLASSEMENT AU FEU: Ame pleine; NOM DU MODELE: 1V EI30 - Portaphone - HB; URL 1 (FICHE TECHNIQUE): ..\01_FICHES_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\PORTES_SIMPLES\3-MBA-051_1V EI30 - Portaphone - HB.pdf; NOM DE L'ELEMENT: PORTES_SIMPLES; NOM DU BATIMENT: BIO; ISSUE DE SECOURS: no; TYPE DE PORTE: BOIS; HUISSERIE: BOIS; MATERIAU PANNEAU: Cadre bois exo. + ame pleine; IMPOSTE: no; PAUMELLES: Universelle Inox; URL 3 (PLANS 2D): ..\02_PLANS_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\LPA-L04-PLA-TN-E-5514_Repérage LPA_PRT.pdf; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.3.1; GEM_ROP_REPERE CCTP: F; Contraintes - Niveau: N0_FINI; Hauteur de l'appui: -0.01 m; Données d'identification - Identifiant: 8; Graphismes - Angle d'ouverture 3D: 0 deg; Angle d'ouverture 2D fixe: yes; Texte - TALON: 0.01
5 x PRT_SIMPLE_HUI_58x68x48 | Instance | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 552385 | Portes | Famille : Portes : PRT_SIMPLE_HUI_58x68x48 | Cotes - Epaisseur: 0.04 m; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Largeur: 0.93 m; Hauteur: 2.047 m; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; Autre - Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Données d'identification - Nom du type: PRT_BOIS_1V_930x2040x40; Paramètres IFC - Exporter le type au format IFC: 0; Opération: SingleSwingLeft; Propriétés analytiques - Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Construction - Fermeture du mur: 0; Fonction: 0; Données - PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; Protection contre les incendies - CLASSEMENT AU FEU: Ame pleine
PRT_SIMPLE_HUI_58x68x48 | PRT_BOIS_1V_930x2040x40 | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 336958 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: PRT_BOIS_1V_930x2040x40; Famille: PRT_BOIS_1V_930x2040x40; Type: PRT_BOIS_1V_930x2040x40; ID du type: PRT_BOIS_1V_930x2040x40; ID hôte: 23_CLS_95/70_1BA13_EIXX_31db; Hauteur sous linteau: 2.037 m; wwwww: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 2.18516 m2; Volume: 0.076475 m3; POIGNEE_DC_PR: 0.0485 m; HAUTEUR LIBRE: 2.0345 m; PASSAGE LIBRE: 0.864002 m; UP: 1; Type de Revit - Id: 552220; Nom: PRT_BOIS_1V_930x2040x40; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : PRT_SIMPLE_HUI_58x68x48; Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Nom du type: PRT_BOIS_1V_930x2040x40; Fonction: 0; Largeur: 0.93 m; 01RVZ_CLASSIFICATIONS: 51_PORTES INTERIEUR; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Identifiant du type: 38; Fermeture du mur: 0; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Hauteur: 2.047 m; Opération: SingleSwingLeft; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; CLASSEMENT AU FEU: Ame pleine; NOM DU MODELE: 1V EI30 - Portaphone - HB; URL 1 (FICHE TECHNIQUE): ..\01_FICHES_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\PORTES_SIMPLES\3-MBA-051_1V EI30 - Portaphone - HB.pdf; NOM DE L'ELEMENT: PORTES_SIMPLES; NOM DU BATIMENT: BIO; ISSUE DE SECOURS: no; TYPE DE PORTE: BOIS; HUISSERIE: BOIS; MATERIAU PANNEAU: Cadre bois exo. + ame pleine; IMPOSTE: no; PAUMELLES: Universelle Inox; URL 3 (PLANS 2D): ..\02_PLANS_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\LPA-L04-PLA-TN-E-5514_Repérage LPA_PRT.pdf; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.3.1; GEM_ROP_REPERE CCTP: F; Contraintes - Niveau: N0_FINI; Hauteur de l'appui: -0.01 m; Données d'identification - Identifiant: 10; Graphismes - Angle d'ouverture 3D: 0 deg; Angle d'ouverture 2D fixe: yes; Texte - TALON: 0.01
PRT_SIMPLE_HUI_58x68x48 | PRT_BOIS_1V_930x2040x40 | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 336991 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: PRT_BOIS_1V_930x2040x40; Famille: PRT_BOIS_1V_930x2040x40; Type: PRT_BOIS_1V_930x2040x40; ID du type: PRT_BOIS_1V_930x2040x40; ID hôte: 23_CLS_95/70_1BA13_EIXX_31db; Hauteur sous linteau: 2.037 m; wwwww: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 2.18516 m2; Volume: 0.076475 m3; POIGNEE_DC_PR: 0.0485 m; HAUTEUR LIBRE: 2.0345 m; PASSAGE LIBRE: 0.864002 m; UP: 1; Type de Revit - Id: 552220; Nom: PRT_BOIS_1V_930x2040x40; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : PRT_SIMPLE_HUI_58x68x48; Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Nom du type: PRT_BOIS_1V_930x2040x40; Fonction: 0; Largeur: 0.93 m; 01RVZ_CLASSIFICATIONS: 51_PORTES INTERIEUR; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Identifiant du type: 38; Fermeture du mur: 0; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Hauteur: 2.047 m; Opération: SingleSwingLeft; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; CLASSEMENT AU FEU: Ame pleine; NOM DU MODELE: 1V EI30 - Portaphone - HB; URL 1 (FICHE TECHNIQUE): ..\01_FICHES_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\PORTES_SIMPLES\3-MBA-051_1V EI30 - Portaphone - HB.pdf; NOM DE L'ELEMENT: PORTES_SIMPLES; NOM DU BATIMENT: BIO; ISSUE DE SECOURS: no; TYPE DE PORTE: BOIS; HUISSERIE: BOIS; MATERIAU PANNEAU: Cadre bois exo. + ame pleine; IMPOSTE: no; PAUMELLES: Universelle Inox; URL 3 (PLANS 2D): ..\02_PLANS_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\LPA-L04-PLA-TN-E-5514_Repérage LPA_PRT.pdf; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.3.1; GEM_ROP_REPERE CCTP: F; Contraintes - Niveau: N0_FINI; Hauteur de l'appui: -0.01 m; Données d'identification - Identifiant: 11; Graphismes - Angle d'ouverture 3D: 0 deg; Angle d'ouverture 2D fixe: yes; Texte - TALON: 0.01
PRT_SIMPLE_HUI_58x68x48 | PRT_BOIS_1V_930x2040x40 | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 336997 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: PRT_BOIS_1V_930x2040x40; Famille: PRT_BOIS_1V_930x2040x40; Type: PRT_BOIS_1V_930x2040x40; ID du type: PRT_BOIS_1V_930x2040x40; ID hôte: 23_CLS_95/70_1BA13_EIXX_31db; Hauteur sous linteau: 2.037 m; wwwww: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 2.18516 m2; Volume: 0.076475 m3; POIGNEE_DC_PR: 0.0485 m; HAUTEUR LIBRE: 2.0345 m; PASSAGE LIBRE: 0.864002 m; UP: 1; Type de Revit - Id: 552220; Nom: PRT_BOIS_1V_930x2040x40; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : PRT_SIMPLE_HUI_58x68x48; Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Nom du type: PRT_BOIS_1V_930x2040x40; Fonction: 0; Largeur: 0.93 m; 01RVZ_CLASSIFICATIONS: 51_PORTES INTERIEUR; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Identifiant du type: 38; Fermeture du mur: 0; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Hauteur: 2.047 m; Opération: SingleSwingLeft; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; CLASSEMENT AU FEU: Ame pleine; NOM DU MODELE: 1V EI30 - Portaphone - HB; URL 1 (FICHE TECHNIQUE): ..\01_FICHES_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\PORTES_SIMPLES\3-MBA-051_1V EI30 - Portaphone - HB.pdf; NOM DE L'ELEMENT: PORTES_SIMPLES; NOM DU BATIMENT: BIO; ISSUE DE SECOURS: no; TYPE DE PORTE: BOIS; HUISSERIE: BOIS; MATERIAU PANNEAU: Cadre bois exo. + ame pleine; IMPOSTE: no; PAUMELLES: Universelle Inox; URL 3 (PLANS 2D): ..\02_PLANS_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\LPA-L04-PLA-TN-E-5514_Repérage LPA_PRT.pdf; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.3.1; GEM_ROP_REPERE CCTP: F; Contraintes - Niveau: N0_FINI; Hauteur de l'appui: -0.01 m; Données d'identification - Identifiant: 12; Graphismes - Angle d'ouverture 3D: 0 deg; Angle d'ouverture 2D fixe: yes; Texte - TALON: 0.01
PRT_SIMPLE_HUI_58x68x48 | Instance | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 552383 | Portes | Famille : Portes : PRT_SIMPLE_HUI_58x68x48 | Cotes - Epaisseur: 0.04 m; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Largeur: 0.93 m; Hauteur: 2.047 m; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; Autre - Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Données d'identification - Nom du type: PRT_BOIS_1V_930x2040x40; Paramètres IFC - Exporter le type au format IFC: 0; Opération: SingleSwingLeft; Propriétés analytiques - Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Construction - Fermeture du mur: 0; Fonction: 0; Données - PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; Protection contre les incendies - CLASSEMENT AU FEU: Ame pleine
PRT_SIMPLE_HUI_58x68x48 | PRT_BOIS_1V_930x2040x40 | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 337041 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: PRT_BOIS_1V_930x2040x40; Famille: PRT_BOIS_1V_930x2040x40; Type: PRT_BOIS_1V_930x2040x40; ID du type: PRT_BOIS_1V_930x2040x40; ID hôte: 23_CLS_95/70_1BA13_EIXX_31db; Hauteur sous linteau: 2.037 m; wwwww: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 2.18516 m2; Volume: 0.076475 m3; POIGNEE_DC_PR: 0.0485 m; HAUTEUR LIBRE: 2.0345 m; PASSAGE LIBRE: 0.864002 m; UP: 1; Type de Revit - Id: 552220; Nom: PRT_BOIS_1V_930x2040x40; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : PRT_SIMPLE_HUI_58x68x48; Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Nom du type: PRT_BOIS_1V_930x2040x40; Fonction: 0; Largeur: 0.93 m; 01RVZ_CLASSIFICATIONS: 51_PORTES INTERIEUR; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Identifiant du type: 38; Fermeture du mur: 0; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Hauteur: 2.047 m; Opération: SingleSwingLeft; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; CLASSEMENT AU FEU: Ame pleine; NOM DU MODELE: 1V EI30 - Portaphone - HB; URL 1 (FICHE TECHNIQUE): ..\01_FICHES_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\PORTES_SIMPLES\3-MBA-051_1V EI30 - Portaphone - HB.pdf; NOM DE L'ELEMENT: PORTES_SIMPLES; NOM DU BATIMENT: BIO; ISSUE DE SECOURS: no; TYPE DE PORTE: BOIS; HUISSERIE: BOIS; MATERIAU PANNEAU: Cadre bois exo. + ame pleine; IMPOSTE: no; PAUMELLES: Universelle Inox; URL 3 (PLANS 2D): ..\02_PLANS_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\LPA-L04-PLA-TN-E-5514_Repérage LPA_PRT.pdf; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.3.1; GEM_ROP_REPERE CCTP: F; Contraintes - Niveau: N0_FINI; Hauteur de l'appui: -0.01 m; Données d'identification - Identifiant: 13; Graphismes - Angle d'ouverture 3D: 0 deg; Angle d'ouverture 2D fixe: yes; Texte - TALON: 0.01
PRT_SIMPLE_HUI_58x68x48 | PRT_BOIS_1V_930x2040x40 | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 337095 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: PRT_BOIS_1V_930x2040x40; Famille: PRT_BOIS_1V_930x2040x40; Type: PRT_BOIS_1V_930x2040x40; ID du type: PRT_BOIS_1V_930x2040x40; ID hôte: 23_CLS_95/70_1BA13_EIXX_31db; Hauteur sous linteau: 2.037 m; wwwww: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 2.18516 m2; Volume: 0.076475 m3; POIGNEE_DC_PR: 0.0485 m; HAUTEUR LIBRE: 2.0345 m; PASSAGE LIBRE: 0.864002 m; UP: 1; Type de Revit - Id: 552220; Nom: PRT_BOIS_1V_930x2040x40; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : PRT_SIMPLE_HUI_58x68x48; Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Nom du type: PRT_BOIS_1V_930x2040x40; Fonction: 0; Largeur: 0.93 m; 01RVZ_CLASSIFICATIONS: 51_PORTES INTERIEUR; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Identifiant du type: 38; Fermeture du mur: 0; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Hauteur: 2.047 m; Opération: SingleSwingLeft; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; CLASSEMENT AU FEU: Ame pleine; NOM DU MODELE: 1V EI30 - Portaphone - HB; URL 1 (FICHE TECHNIQUE): ..\01_FICHES_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\PORTES_SIMPLES\3-MBA-051_1V EI30 - Portaphone - HB.pdf; NOM DE L'ELEMENT: PORTES_SIMPLES; NOM DU BATIMENT: BIO; ISSUE DE SECOURS: no; TYPE DE PORTE: BOIS; HUISSERIE: BOIS; MATERIAU PANNEAU: Cadre bois exo. + ame pleine; IMPOSTE: no; PAUMELLES: Universelle Inox; URL 3 (PLANS 2D): ..\02_PLANS_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\LPA-L04-PLA-TN-E-5514_Repérage LPA_PRT.pdf; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.3.1; GEM_ROP_REPERE CCTP: F; Contraintes - Niveau: N0_FINI; Hauteur de l'appui: -0.01 m; Données d'identification - Identifiant: 14; Graphismes - Angle d'ouverture 3D: 0 deg; Angle d'ouverture 2D fixe: yes; Texte - TALON: 0.01
PRT_SIMPLE_HUI_58x68x48 | PRT_BOIS_1V_930x2040x40 | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 337275 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: PRT_BOIS_1V_930x2040x40; Famille: PRT_BOIS_1V_930x2040x40; Type: PRT_BOIS_1V_930x2040x40; ID du type: PRT_BOIS_1V_930x2040x40; ID hôte: 23_CLS_95/70_1BA13_EIXX_31db; Hauteur sous linteau: 2.037 m; wwwww: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 2.18516 m2; Volume: 0.076475 m3; POIGNEE_DC_PR: 0.0485 m; HAUTEUR LIBRE: 2.0345 m; PASSAGE LIBRE: 0.864002 m; UP: 1; Type de Revit - Id: 552220; Nom: PRT_BOIS_1V_930x2040x40; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : PRT_SIMPLE_HUI_58x68x48; Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Nom du type: PRT_BOIS_1V_930x2040x40; Fonction: 0; Largeur: 0.93 m; 01RVZ_CLASSIFICATIONS: 51_PORTES INTERIEUR; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Identifiant du type: 38; Fermeture du mur: 0; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Hauteur: 2.047 m; Opération: SingleSwingLeft; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; CLASSEMENT AU FEU: Ame pleine; NOM DU MODELE: 1V EI30 - Portaphone - HB; URL 1 (FICHE TECHNIQUE): ..\01_FICHES_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\PORTES_SIMPLES\3-MBA-051_1V EI30 - Portaphone - HB.pdf; NOM DE L'ELEMENT: PORTES_SIMPLES; NOM DU BATIMENT: BIO; ISSUE DE SECOURS: no; TYPE DE PORTE: BOIS; HUISSERIE: BOIS; MATERIAU PANNEAU: Cadre bois exo. + ame pleine; IMPOSTE: no; PAUMELLES: Universelle Inox; URL 3 (PLANS 2D): ..\02_PLANS_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\LPA-L04-PLA-TN-E-5514_Repérage LPA_PRT.pdf; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.3.1; GEM_ROP_REPERE CCTP: F; Contraintes - Niveau: N0_FINI; Hauteur de l'appui: -0.01 m; Données d'identification - Identifiant: 16; Graphismes - Angle d'ouverture 3D: 0 deg; Angle d'ouverture 2D fixe: yes; Texte - TALON: 0.01
PRT_SIMPLE_HUI_58x68x48 | PRT_BOIS_1V_930x2040x40 | PRT_SIMPLE_HUI_58x68x48 | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 338222 | Portes | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: PRT_BOIS_1V_930x2040x40; Famille: PRT_BOIS_1V_930x2040x40; Type: PRT_BOIS_1V_930x2040x40; ID du type: PRT_BOIS_1V_930x2040x40; ID hôte: 23_CLS_95/70_1BA13_EIXX_31db; Hauteur sous linteau: 2.037 m; wwwww: yes; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: DOOR; Exporter au format IFC sous: IfcDoorType; Revizto - Architecture: yes; Cotes - Surface: 2.18516 m2; Volume: 0.076475 m3; POIGNEE_DC_PR: 0.0485 m; HAUTEUR LIBRE: 2.0345 m; PASSAGE LIBRE: 0.864002 m; UP: 1; Type de Revit - Id: 552220; Nom: PRT_BOIS_1V_930x2040x40; Catégorie: Portes; Exporter le type au format IFC: 0; Sous-projet: Famille : Portes : PRT_SIMPLE_HUI_58x68x48; Nom de la famille: PRT_SIMPLE_HUI_58x68x48; Nom du type: PRT_BOIS_1V_930x2040x40; Fonction: 0; Largeur: 0.93 m; 01RVZ_CLASSIFICATIONS: 51_PORTES INTERIEUR; Epaisseur: 0.04 m; Définir les propriétés thermiques par: 1; ID de type de construction: DOOR; Construction analytique: En bois; Transmission de la lumière visible: 0; Coefficient d'apport thermique solaire: 0; Résistance thermique (R): 0.4557 (m²·K)/W; Coefficient de transfert thermique (U): 2.1944 W/(m²·K); Identifiant du type: 38; Fermeture du mur: 0; Largeur brute: 1.0108 m; Hauteur brute: 2.0879 m; Hauteur: 2.047 m; Opération: SingleSwingLeft; Largeur - Ouvrant: 0.93 m; E1: 0.0399 m; E2: 0.0409 m; Largeur ouvrant: 0.04 m; PR5 - PLAQUE_PROTECTION_VI: no; POIGNEE_STOCKHOLM_VI: yes; ROSACE_POIGNEE_VI: yes; SERRURE_VI: yes; PANNEAU_DETALONNAGE: 0.007 m; JOINT_BALAI_DC_HT: 0 m; POIGNEE_DC: 0.06 m; POIGNEE_HT: 1 m; CLASSEMENT AU FEU: Ame pleine; NOM DU MODELE: 1V EI30 - Portaphone - HB; URL 1 (FICHE TECHNIQUE): ..\01_FICHES_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\PORTES_SIMPLES\3-MBA-051_1V EI30 - Portaphone - HB.pdf; NOM DE L'ELEMENT: PORTES_SIMPLES; NOM DU BATIMENT: BIO; ISSUE DE SECOURS: no; TYPE DE PORTE: BOIS; HUISSERIE: BOIS; MATERIAU PANNEAU: Cadre bois exo. + ame pleine; IMPOSTE: no; PAUMELLES: Universelle Inox; URL 3 (PLANS 2D): ..\02_PLANS_TECHNIQUES\04I_MENUISERIE_BOIS_AGENCEMENT\LPA-L04-PLA-TN-E-5514_Repérage LPA_PRT.pdf; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.3.1; GEM_ROP_REPERE CCTP: F; Contraintes - Niveau: N0_FINI; Hauteur de l'appui: -0.01 m; Données d'identification - Identifiant: 17; Graphismes - Angle d'ouverture 3D: 0 deg; Angle d'ouverture 2D fixe: yes; Texte - TALON: 0.01
