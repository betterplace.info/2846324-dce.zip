Properties of the parts of a building model (IFC4), part 2 of 11

# IfcBuildingElementPart (663)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
Mur de base | 23_CCL_115mm | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 300751 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 23_CCL_115mm; Famille: 23_CCL_115mm; Type: 23_CCL_115mm; ID du type: 23_CCL_115mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 0 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.13205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 6.822 m2; Volume: 0.784107 m3; Longueur: 2.72245 m; Type de Revit - Id: 300100; Nom: 23_CCL_115mm; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 23_CCL_115mm; Note d'identification: 23_CLOISON; Commentaires du type: Int. Brique 110 mm; Matériau structurel: 22-Isolation intérieur; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 0; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 0; Largeur: 0.115 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS
21-Mur bloc manufacturé 15cm | Type | 21-Mur bloc manufacturé 15cm | N0_FINI
Mur de base | 21-Mur bloc manufacturé 15cm | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 308626 | Murs | B02_ARC | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 21-Mur bloc manufacturé 15cm; Famille: 21-Mur bloc manufacturé 15cm; Type: 21-Mur bloc manufacturé 15cm; ID du type: 21-Mur bloc manufacturé 15cm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: 0 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 2; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: 0 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 2.75 m; Limite de pièce: yes; Cotes - Surface: 0.301343 m2; Volume: 0.0452014 m3; Longueur: 0.109579 m; Type de Revit - Id: 255945; Nom: 21-Mur bloc manufacturé 15cm; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 21-Mur bloc manufacturé 15cm; Note d'identification: 21_MUR NON PORTEUR; Matériau structurel: 21-Bloc manufacturé; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 0; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.15 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0
43-PAR_BA25 | Type | 43-PAR_BA25 | N0_FINI
Mur de base | 43-PAR_BA25 | Mur de base | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 435270 | Murs | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 43-PAR_BA25; Famille: 43-PAR_BA25; Type: 43-PAR_BA25; ID du type: 43-PAR_BA25; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Décalage inférieur: -0.01 m; Extension inférieure: 0 m; Extension supérieure: 0 m; Lié au volume: no; Ligne de justification: 3; Partie inférieure attachée: no; Partie supérieure attachée: no; Décalage supérieur: -0.35 m; Contrainte inférieure: N0_FINI; Hauteur non contrainte: 3.14205 m; Contrainte supérieure: TT; Limite de pièce: yes; Cotes - Surface: 14.8659 m2; Volume: 0.371642 m3; Longueur: 4.73745 m; Type de Revit - Id: 257013; Nom: 43-PAR_BA25; Catégorie: Murs; Exporter le type au format IFC: 0; Sous-projet: Types de murs; Nom de la famille: Mur de base; Nom du type: 43-PAR_BA25; Note d'identification: 23_CLOISON; Commentaires du type: Ext. Brique 22; Matériau structurel: 22-Plaque de platre; Rugosité: 3; Coefficient d'absorbance: 0.7; Retournement aux insertions: 0; Retournement aux extrémités: 0; Couleur vue détail faible: 0; Fonction: 1; Largeur: 0.025 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Définition de la coupe transversale - Coupe transversale: 1; Phase de construction - Phase de création: Existante; Structure - Structure: no; Utilisation structurelle: 0; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 01; GEM_ROP_NOM DU LOT: MEUNUISERIES INTERIEURS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: TYPE B
Mur-rideau | Family | Mur-rideau | N0_FINI
Simple panneau | Type | Simple panneau | N0_FINI
Sols | Category | Sols | N0_FINI
Sol | Family | Sol | N0_FINI
34_RAGREAGE 8mm | Type | 34_RAGREAGE 8mm | N0_FINI
Sol | 34_RAGREAGE 8mm | Sol | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 316191 | Sols | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 34_RAGREAGE 8mm; Famille: 34_RAGREAGE 8mm; Type: 34_RAGREAGE 8mm; ID du type: 34_RAGREAGE 8mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: -0.002 m; Cotes - Surface: 20.9391 m2; Volume: 0.167513 m3; Périmètre: 18.308 m; Epaisseur: 0.008 m; Elévation au niveau du noyau inférieur: 2.85522e-17 m; Elévation au niveau du noyau supérieur: 0.008 m; Elévation en haut: 0.008 m; Elévation à la base: 2.85522e-17 m; Type de Revit - Id: 316193; Nom: 34_RAGREAGE 8mm; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 34_RAGREAGE 8mm; Note d'identification: 44_SOL FINITION; Matériau structurel: 23_RAGREAGE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.008 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: -; Données d'identification - A une association: no
Sol | 34_RAGREAGE 8mm | Sol | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 316302 | Sols | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 34_RAGREAGE 8mm; Famille: 34_RAGREAGE 8mm; Type: 34_RAGREAGE 8mm; ID du type: 34_RAGREAGE 8mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: -0.002 m; Cotes - Surface: 20.4155 m2; Volume: 0.163324 m3; Périmètre: 20.1805 m; Epaisseur: 0.008 m; Elévation au niveau du noyau inférieur: 2.85522e-17 m; Elévation au niveau du noyau supérieur: 0.008 m; Elévation en haut: 0.008 m; Elévation à la base: 2.85522e-17 m; Type de Revit - Id: 316193; Nom: 34_RAGREAGE 8mm; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 34_RAGREAGE 8mm; Note d'identification: 44_SOL FINITION; Matériau structurel: 23_RAGREAGE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.008 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: -; Données d'identification - A une association: no
Sol | 34_RAGREAGE 8mm | Sol | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 316406 | Sols | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 34_RAGREAGE 8mm; Famille: 34_RAGREAGE 8mm; Type: 34_RAGREAGE 8mm; ID du type: 34_RAGREAGE 8mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: -0.002 m; Cotes - Surface: 51.5697 m2; Volume: 0.412558 m3; Périmètre: 29.1988 m; Epaisseur: 0.008 m; Elévation au niveau du noyau inférieur: 2.85522e-17 m; Elévation au niveau du noyau supérieur: 0.008 m; Elévation en haut: 0.008 m; Elévation à la base: 2.85522e-17 m; Type de Revit - Id: 316193; Nom: 34_RAGREAGE 8mm; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 34_RAGREAGE 8mm; Note d'identification: 44_SOL FINITION; Matériau structurel: 23_RAGREAGE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.008 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: -; Données d'identification - A une association: no
Sol | 34_RAGREAGE 8mm | Sol | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 316451 | Sols | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 34_RAGREAGE 8mm; Famille: 34_RAGREAGE 8mm; Type: 34_RAGREAGE 8mm; ID du type: 34_RAGREAGE 8mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: -0.002 m; Cotes - Surface: 75.0991 m2; Volume: 0.600793 m3; Périmètre: 77.1972 m; Epaisseur: 0.008 m; Elévation au niveau du noyau inférieur: 2.85522e-17 m; Elévation au niveau du noyau supérieur: 0.008 m; Elévation en haut: 0.008 m; Elévation à la base: 2.85522e-17 m; Type de Revit - Id: 316193; Nom: 34_RAGREAGE 8mm; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 34_RAGREAGE 8mm; Note d'identification: 44_SOL FINITION; Matériau structurel: 23_RAGREAGE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.008 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: -; Données d'identification - A une association: no
Sol | 34_RAGREAGE 8mm | Sol | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 318092 | Sols | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 34_RAGREAGE 8mm; Famille: 34_RAGREAGE 8mm; Type: 34_RAGREAGE 8mm; ID du type: 34_RAGREAGE 8mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: -0.002 m; Cotes - Surface: 6.23069 m2; Volume: 0.0498455 m3; Périmètre: 10.5747 m; Epaisseur: 0.008 m; Elévation au niveau du noyau inférieur: 2.85522e-17 m; Elévation au niveau du noyau supérieur: 0.008 m; Elévation en haut: 0.008 m; Elévation à la base: 2.85522e-17 m; Type de Revit - Id: 316193; Nom: 34_RAGREAGE 8mm; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 34_RAGREAGE 8mm; Note d'identification: 44_SOL FINITION; Matériau structurel: 23_RAGREAGE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.008 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: -; Données d'identification - A une association: no
Sol | 34_RAGREAGE 8mm | Sol | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 318172 | Sols | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 34_RAGREAGE 8mm; Famille: 34_RAGREAGE 8mm; Type: 34_RAGREAGE 8mm; ID du type: 34_RAGREAGE 8mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: -0.002 m; Cotes - Surface: 6.11753 m2; Volume: 0.0489403 m3; Périmètre: 10.3047 m; Epaisseur: 0.008 m; Elévation au niveau du noyau inférieur: 2.85522e-17 m; Elévation au niveau du noyau supérieur: 0.008 m; Elévation en haut: 0.008 m; Elévation à la base: 2.85522e-17 m; Type de Revit - Id: 316193; Nom: 34_RAGREAGE 8mm; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 34_RAGREAGE 8mm; Note d'identification: 44_SOL FINITION; Matériau structurel: 23_RAGREAGE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.008 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: -; Données d'identification - A une association: no
Sol | 34_RAGREAGE 8mm | Sol | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 318217 | Sols | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 34_RAGREAGE 8mm; Famille: 34_RAGREAGE 8mm; Type: 34_RAGREAGE 8mm; ID du type: 34_RAGREAGE 8mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: -0.002 m; Cotes - Surface: 5.76715 m2; Volume: 0.0461372 m3; Périmètre: 9.66963 m; Epaisseur: 0.008 m; Elévation au niveau du noyau inférieur: 2.85522e-17 m; Elévation au niveau du noyau supérieur: 0.008 m; Elévation en haut: 0.008 m; Elévation à la base: 2.85522e-17 m; Type de Revit - Id: 316193; Nom: 34_RAGREAGE 8mm; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 34_RAGREAGE 8mm; Note d'identification: 44_SOL FINITION; Matériau structurel: 23_RAGREAGE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.008 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: -; Données d'identification - A une association: no
Sol | 34_RAGREAGE 8mm | Sol | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 318248 | Sols | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 34_RAGREAGE 8mm; Famille: 34_RAGREAGE 8mm; Type: 34_RAGREAGE 8mm; ID du type: 34_RAGREAGE 8mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: -0.002 m; Cotes - Surface: 3.23331 m2; Volume: 0.0258665 m3; Périmètre: 7.78866 m; Epaisseur: 0.008 m; Elévation au niveau du noyau inférieur: 2.85522e-17 m; Elévation au niveau du noyau supérieur: 0.008 m; Elévation en haut: 0.008 m; Elévation à la base: 2.85522e-17 m; Type de Revit - Id: 316193; Nom: 34_RAGREAGE 8mm; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 34_RAGREAGE 8mm; Note d'identification: 44_SOL FINITION; Matériau structurel: 23_RAGREAGE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.008 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: -; Données d'identification - A une association: no
Sol | 34_RAGREAGE 8mm | Sol | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 318279 | Sols | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 34_RAGREAGE 8mm; Famille: 34_RAGREAGE 8mm; Type: 34_RAGREAGE 8mm; ID du type: 34_RAGREAGE 8mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: -0.002 m; Cotes - Surface: 3.24526 m2; Volume: 0.0259621 m3; Périmètre: 7.80877 m; Epaisseur: 0.008 m; Elévation au niveau du noyau inférieur: 2.85522e-17 m; Elévation au niveau du noyau supérieur: 0.008 m; Elévation en haut: 0.008 m; Elévation à la base: 2.85522e-17 m; Type de Revit - Id: 316193; Nom: 34_RAGREAGE 8mm; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 34_RAGREAGE 8mm; Note d'identification: 44_SOL FINITION; Matériau structurel: 23_RAGREAGE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.008 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: -; Données d'identification - A une association: no
Sol | 34_RAGREAGE 8mm | Sol | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 318341 | Sols | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 34_RAGREAGE 8mm; Famille: 34_RAGREAGE 8mm; Type: 34_RAGREAGE 8mm; ID du type: 34_RAGREAGE 8mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: -0.002 m; Cotes - Surface: 27.3836 m2; Volume: 0.219068 m3; Périmètre: 21.6411 m; Epaisseur: 0.008 m; Elévation au niveau du noyau inférieur: 2.85522e-17 m; Elévation au niveau du noyau supérieur: 0.008 m; Elévation en haut: 0.008 m; Elévation à la base: 2.85522e-17 m; Type de Revit - Id: 316193; Nom: 34_RAGREAGE 8mm; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 34_RAGREAGE 8mm; Note d'identification: 44_SOL FINITION; Matériau structurel: 23_RAGREAGE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.008 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: -; Données d'identification - A une association: no
Sol | 34_RAGREAGE 8mm | Sol | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 318399 | Sols | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 34_RAGREAGE 8mm; Famille: 34_RAGREAGE 8mm; Type: 34_RAGREAGE 8mm; ID du type: 34_RAGREAGE 8mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: -0.002 m; Cotes - Surface: 28.3231 m2; Volume: 0.226584 m3; Périmètre: 21.8885 m; Epaisseur: 0.008 m; Elévation au niveau du noyau inférieur: 2.85522e-17 m; Elévation au niveau du noyau supérieur: 0.008 m; Elévation en haut: 0.008 m; Elévation à la base: 2.85522e-17 m; Type de Revit - Id: 316193; Nom: 34_RAGREAGE 8mm; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 34_RAGREAGE 8mm; Note d'identification: 44_SOL FINITION; Matériau structurel: 23_RAGREAGE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.008 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: -; Données d'identification - A une association: no
Sol | 34_RAGREAGE 8mm | Sol | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 318457 | Sols | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 34_RAGREAGE 8mm; Famille: 34_RAGREAGE 8mm; Type: 34_RAGREAGE 8mm; ID du type: 34_RAGREAGE 8mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: -0.002 m; Cotes - Surface: 28.1751 m2; Volume: 0.225401 m3; Périmètre: 21.4842 m; Epaisseur: 0.008 m; Elévation au niveau du noyau inférieur: 2.85522e-17 m; Elévation au niveau du noyau supérieur: 0.008 m; Elévation en haut: 0.008 m; Elévation à la base: 2.85522e-17 m; Type de Revit - Id: 316193; Nom: 34_RAGREAGE 8mm; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 34_RAGREAGE 8mm; Note d'identification: 44_SOL FINITION; Matériau structurel: 23_RAGREAGE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.008 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: -; Données d'identification - A une association: no
Sol | 34_RAGREAGE 8mm | Sol | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 318967 | Sols | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 34_RAGREAGE 8mm; Famille: 34_RAGREAGE 8mm; Type: 34_RAGREAGE 8mm; ID du type: 34_RAGREAGE 8mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: -0.002 m; Cotes - Surface: 20.0334 m2; Volume: 0.160267 m3; Périmètre: 23.2439 m; Epaisseur: 0.008 m; Elévation au niveau du noyau inférieur: 2.85522e-17 m; Elévation au niveau du noyau supérieur: 0.008 m; Elévation en haut: 0.008 m; Elévation à la base: 2.85522e-17 m; Type de Revit - Id: 316193; Nom: 34_RAGREAGE 8mm; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 34_RAGREAGE 8mm; Note d'identification: 44_SOL FINITION; Matériau structurel: 23_RAGREAGE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.008 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: -; Données d'identification - A une association: no
Sol | 34_RAGREAGE 8mm | Sol | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 369462 | Sols | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 34_RAGREAGE 8mm; Famille: 34_RAGREAGE 8mm; Type: 34_RAGREAGE 8mm; ID du type: 34_RAGREAGE 8mm; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Structure: yes; Contraintes - Lié au volume: no; Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: -0.002 m; Cotes - Surface: 24.5892 m2; Volume: 0.196713 m3; Périmètre: 21.1428 m; Epaisseur: 0.008 m; Elévation au niveau du noyau inférieur: 2.85522e-17 m; Elévation au niveau du noyau supérieur: 0.008 m; Elévation en haut: 0.008 m; Elévation à la base: 2.85522e-17 m; Type de Revit - Id: 316193; Nom: 34_RAGREAGE 8mm; Catégorie: Sols; Exporter le type au format IFC: 0; Sous-projet: Types de sols; Nom de la famille: Sol; Nom du type: 34_RAGREAGE 8mm; Note d'identification: 44_SOL FINITION; Matériau structurel: 23_RAGREAGE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Fonction: 0; Epaisseur par défaut: 0.008 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Structure - Structure: no; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 04; GEM_ROP_NOM DU LOT: REVETEMENTS DE SOLS; GEM_ROP_LIGNE CCTP: 12.1.2; GEM_ROP_REPERE CCTP: -; Données d'identification - A une association: no
44_SOL TYPE A | Type | 44_SOL TYPE A | N0_FINI
Plafonds | Category | Plafonds | N0_FINI
Plafond composé | Family | Plafond composé | N0_FINI
45_DALLE 600x600_TYPE A | Type | 45_DALLE 600x600_TYPE A | N0_FINI
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 321326 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 19.6212 m2; Volume: 0.392425 m3; Périmètre: 27.492 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 321362 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 19.427 m2; Volume: 0.388541 m3; Périmètre: 27.0685 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 321412 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 5.90121 m2; Volume: 0.118024 m3; Périmètre: 12.8707 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 321480 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 5.78806 m2; Volume: 0.115761 m3; Périmètre: 12.6007 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 321532 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 23.6271 m2; Volume: 0.472543 m3; Périmètre: 30.3661 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 321581 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 25.8702 m2; Volume: 0.517404 m3; Périmètre: 30.5285 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 321639 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 26.8547 m2; Volume: 0.537095 m3; Périmètre: 30.6675 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 321705 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 26.8572 m2; Volume: 0.537144 m3; Périmètre: 30.6682 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 321744 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 15.3427 m2; Volume: 0.306854 m3; Périmètre: 21.6402 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 321793 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 5.72002 m2; Volume: 0.1144 m3; Périmètre: 10.7633 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 321828 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 3.20953 m2; Volume: 0.0641906 m3; Périmètre: 8.3353 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 321939 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 3.22148 m2; Volume: 0.0644296 m3; Périmètre: 8.35541 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 322000 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.4 m; Cotes - Surface: 7.79383 m2; Volume: 0.155877 m3; Périmètre: 21.3803 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 322042 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 5.10118 m2; Volume: 0.102024 m3; Périmètre: 12.1672 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 322078 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.4 m; Cotes - Surface: 6.66012 m2; Volume: 0.133202 m3; Périmètre: 14.0967 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 322182 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.4 m; Cotes - Surface: 17.437 m2; Volume: 0.348739 m3; Périmètre: 28.0714 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 322271 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.4 m; Cotes - Surface: 1.66897 m2; Volume: 0.0333794 m3; Périmètre: 5.23163 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 322312 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 3.82232 m2; Volume: 0.0764464 m3; Périmètre: 8.90267 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 423131 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.5 m; Cotes - Surface: 27.3339 m2; Volume: 0.546678 m3; Périmètre: 66.7668 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
Plafond composé | 45_DALLE 600x600_TYPE A | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 524243 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 45_DALLE 600x600_TYPE A; Famille: 45_DALLE 600x600_TYPE A; Type: 45_DALLE 600x600_TYPE A; ID du type: 45_DALLE 600x600_TYPE A; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.4 m; Cotes - Surface: 16.2181 m2; Volume: 0.324363 m3; Périmètre: 26.1925 m; Type de Revit - Id: 321133; Nom: 45_DALLE 600x600_TYPE A; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 45_DALLE 600x600_TYPE A; Note d'identification: 25_FAUX-PLAFONDS; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.02 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.1; GEM_ROP_REPERE CCTP: TYPE A
35_ISOLATION 260mm | Type | 35_ISOLATION 260mm | N0_FINI
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 322547 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.52 m; Cotes - Surface: 16.0017 m2; Volume: 4.16043 m3; Périmètre: 17.0482 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 322594 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.52 m; Cotes - Surface: 28.1751 m2; Volume: 7.32553 m3; Périmètre: 21.4842 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 322633 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.52 m; Cotes - Surface: 28.1726 m2; Volume: 7.32488 m3; Périmètre: 21.4835 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
Plafond composé | 35_ISOLATION 260mm | Plafond composé | N0_FINI | CurrentWithCentral | NotOwned | foret-f | 322671 | Plafonds | 2021_015 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Autre - Famille et type: 35_ISOLATION 260mm; Famille: 35_ISOLATION 260mm; Type: 35_ISOLATION 260mm; ID du type: 35_ISOLATION 260mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: INSULATION; Exporter au format IFC sous: IfcCoveringType; Revizto - Architecture: yes; Contraintes - Limite de pièce: yes; Niveau: N0_FINI; Décalage par rapport au niveau: 2.52 m; Cotes - Surface: 27.1881 m2; Volume: 7.0689 m3; Périmètre: 21.3445 m; Type de Revit - Id: 322393; Nom: 35_ISOLATION 260mm; Catégorie: Plafonds; Exporter le type au format IFC: 0; Sous-projet: Types de plafonds; Nom de la famille: Plafond composé; Nom du type: 35_ISOLATION 260mm; Note d'identification: 35_FAUX PLAFOND ELEMENT SECONDAIRE; Rugosité: 3; Coefficient d'absorbance: 0.7; Couleur vue détail faible: 0; Epaisseur: 0.26 m; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existante; Sous-projet: Paramètres des phases; Id: 3; Phase de construction - Phase de création: Existante; Propriétés du modèle - GEM_ROP_NOM: KC; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 06; GEM_ROP_NOM DU LOT: FAUX PLAFOND; GEM_ROP_LIGNE CCTP: 12.2.2; GEM_ROP_REPERE CCTP: TYPE B
