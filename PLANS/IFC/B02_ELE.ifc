Properties of the parts of a building model (IFC4), part 23 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7158475 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6844836 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q34; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.4 m; Niveau de nomenclature: S1; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411271 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 34; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 1 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 300 VA; Courant de Phase C: 0 A; Courant de Phase B: 0 A; Courant de Phase A: 1 A; Intensité requise estimée totale: 1 A; Intensité installée totale: 1 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 300 VA; Puissance apparente installée totale: 300 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 300 VA; Other Estimated Demand: 300 VA; Other Connected: 300 VA; Other Estimated Demand Current: 1 A; Other Connected Current: 1 A; Other Demand Factor: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.2; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Emplacement: COULOIR C001; Nom du panneau: TD1-Q34-BD1; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: PC 230N; Texte - TEXTE 3D: TD1-Q34-BD1
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7158463 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6846161 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q35; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.4 m; Niveau de nomenclature: S1; Cotes - Volume: 0.0000819755 m3; Surface: 0.041159 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 2; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 1 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 200 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 0 A; Courant de Phase B: 1 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 1 A; Intensité installée totale: 1 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 200 VA; Puissance apparente installée totale: 200 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 200 VA; Puissance apparente - Phase A: 0 VA; Other Estimated Demand: 200 VA; Other Connected: 200 VA; Other Estimated Demand Current: 1 A; Other Connected Current: 1 A; Other Demand Factor: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1-Q35-BD2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.8; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Emplacement: GARAGE 003; Nom du panneau: TD1-Q35-BD3; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: PC 230N; Texte - TEXTE 3D: TD1-Q35-BD3
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7158472 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6846180 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.4 m; Niveau de nomenclature: S1; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411696 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 2; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 1 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 172 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 1 A; Courant de Phase B: 0 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 1 A; Intensité installée totale: 1 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 172 VA; Puissance apparente installée totale: 172 VA; Puissance apparente - Phase C: 172 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 0 VA; Puissance apparente requise Autre: 72 VA; Puissance apparente connectée Autre: 72 VA; Autre - Intensité utilisée estimée: 0 A; Autre - Intensité installée: 0 A; Autre - Coefficient d'utilisation: 100.00%; Other Estimated Demand: 100 VA; Other Connected: 100 VA; Other Estimated Demand Current: 0 A; Other Connected Current: 0 A; Other Demand Factor: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1-Q36-BD4; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.8; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Emplacement: GARAGE 003; Nom du panneau: TD1-Q36-BD5; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: ECL; Texte - TEXTE 3D: TD1-Q36-BD5
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7158487 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6916231 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.4 m; Niveau de nomenclature: S1; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411623 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 2; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 4 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 904 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 4 A; Courant de Phase B: 0 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 4 A; Intensité installée totale: 4 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 904 VA; Puissance apparente installée totale: 904 VA; Puissance apparente - Phase C: 904 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 0 VA; Puissance apparente requise Autre: 504 VA; Puissance apparente connectée Autre: 504 VA; Autre - Intensité utilisée estimée: 2 A; Autre - Intensité installée: 2 A; Autre - Coefficient d'utilisation: 100.00%; Other Estimated Demand: 400 VA; Other Connected: 400 VA; Other Estimated Demand Current: 2 A; Other Connected Current: 2 A; Other Demand Factor: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1-Q36-BD1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.2; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Emplacement: COULOIR C001; Nom du panneau: TD1-Q36-BD2; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: ECL; Texte - TEXTE 3D: TD1-Q36-BD2
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7158478 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
Luminaires | Category | Luminaires | S1
604_REGLETTE ETANCHE 120CM | Family | 604_REGLETTE ETANCHE 120CM | S1
604_REGLETTE ETANCHE 120CM | Type | 604_REGLETTE ETANCHE 120CM | S1
604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6880098 | Luminaires | 604_REGLETTE ETANCHE 120CM | 0 | 2021_015 | yes | yes | Modèle Revit lié : B02_DC_STR.rvt | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6879838 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.57 m; Niveau de nomenclature: S1; Cotes - Volume: 0.156244 m3; Surface: 1.11579 m2; Electricité - Charges - Panneau: TD1-Q36-BD4; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-36 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.8; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Hémisphérique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 47 lx; Intensité lumineuse: 439 cd; Efficacité: 149 lm/W; Puissance: 9 W; Facteur de perte de luminosité totale: 1; Flux lumineux: 1380 lm; Note d'identification: 600_ELECTRICITE C.FORTS; Taille du symbole de la source d'éclairage: 0.6096 m; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
13 x 604_REGLETTE ETANCHE 120CM | Instance | 604_REGLETTE ETANCHE 120CM | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6879838 | Luminaires |  |  | Famille : Luminaires : 604_REGLETTE ETANCHE 120CM | Autre - Nom de la famille: 604_REGLETTE ETANCHE 120CM; Données d'identification - Nom du type: 604_REGLETTE ETANCHE 120CM; Note d'identification: 600_ELECTRICITE C.FORTS; Contraintes - Elévation par défaut: 1.2192 m; Photométriques - Définition de la source d'éclairage (famille): Ligne+Hémisphérique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 47 lx; Intensité lumineuse: 439 cd; Efficacité: 149 lm/W; Puissance: 9 W; Facteur de perte de luminosité totale: 1; Flux lumineux: 1380 lm; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Taille du symbole de la source d'éclairage: 0.6096 m
604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6880106 | Luminaires | 604_REGLETTE ETANCHE 120CM | 0 | 2021_015 | yes | yes | Modèle Revit lié : B02_DC_STR.rvt | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6879838 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.57 m; Niveau de nomenclature: S1; Cotes - Volume: 0.156244 m3; Surface: 1.11579 m2; Electricité - Charges - Panneau: TD1-Q36-BD4; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-36 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.8; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Hémisphérique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 47 lx; Intensité lumineuse: 439 cd; Efficacité: 149 lm/W; Puissance: 9 W; Facteur de perte de luminosité totale: 1; Flux lumineux: 1380 lm; Note d'identification: 600_ELECTRICITE C.FORTS; Taille du symbole de la source d'éclairage: 0.6096 m; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6882005 | Luminaires | 604_REGLETTE ETANCHE 120CM | 0 | 2021_015 | yes | yes | Modèle Revit lié : B02_DC_STR.rvt | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6879838 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.57 m; Niveau de nomenclature: S1; Cotes - Volume: 0.156244 m3; Surface: 1.11579 m2; Electricité - Charges - Panneau: TD1-Q36-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-36 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.5; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Hémisphérique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 47 lx; Intensité lumineuse: 439 cd; Efficacité: 149 lm/W; Puissance: 9 W; Facteur de perte de luminosité totale: 1; Flux lumineux: 1380 lm; Note d'identification: 600_ELECTRICITE C.FORTS; Taille du symbole de la source d'éclairage: 0.6096 m; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6882006 | Luminaires | 604_REGLETTE ETANCHE 120CM | 0 | 2021_015 | yes | yes | Modèle Revit lié : B02_DC_STR.rvt | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6879838 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.57 m; Niveau de nomenclature: S1; Cotes - Volume: 0.156244 m3; Surface: 1.11579 m2; Electricité - Charges - Panneau: TD1-Q36-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-36 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.5; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Hémisphérique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 47 lx; Intensité lumineuse: 439 cd; Efficacité: 149 lm/W; Puissance: 9 W; Facteur de perte de luminosité totale: 1; Flux lumineux: 1380 lm; Note d'identification: 600_ELECTRICITE C.FORTS; Taille du symbole de la source d'éclairage: 0.6096 m; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6882041 | Luminaires | 604_REGLETTE ETANCHE 120CM | 0 | 2021_015 | yes | yes | Modèle Revit lié : B02_DC_STR.rvt | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6879838 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.57 m; Niveau de nomenclature: S1; Cotes - Volume: 0.156244 m3; Surface: 1.11579 m2; Electricité - Charges - Panneau: TD1-Q36-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-36 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.5; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Hémisphérique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 47 lx; Intensité lumineuse: 439 cd; Efficacité: 149 lm/W; Puissance: 9 W; Facteur de perte de luminosité totale: 1; Flux lumineux: 1380 lm; Note d'identification: 600_ELECTRICITE C.FORTS; Taille du symbole de la source d'éclairage: 0.6096 m; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6882042 | Luminaires | 604_REGLETTE ETANCHE 120CM | 0 | 2021_015 | yes | yes | Modèle Revit lié : B02_DC_STR.rvt | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6879838 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.57 m; Niveau de nomenclature: S1; Cotes - Volume: 0.156244 m3; Surface: 1.11579 m2; Electricité - Charges - Panneau: TD1-Q36-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-36 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.5; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Hémisphérique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 47 lx; Intensité lumineuse: 439 cd; Efficacité: 149 lm/W; Puissance: 9 W; Facteur de perte de luminosité totale: 1; Flux lumineux: 1380 lm; Note d'identification: 600_ELECTRICITE C.FORTS; Taille du symbole de la source d'éclairage: 0.6096 m; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6884342 | Luminaires | 604_REGLETTE ETANCHE 120CM | 0 | 2021_015 | yes | yes | Modèle Revit lié : B02_DC_STR.rvt | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6879838 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.57 m; Niveau de nomenclature: S1; Cotes - Volume: 0.156244 m3; Surface: 1.11579 m2; Electricité - Charges - Panneau: TD1-Q36-BD3; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-36 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.6; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Hémisphérique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 47 lx; Intensité lumineuse: 439 cd; Efficacité: 149 lm/W; Puissance: 9 W; Facteur de perte de luminosité totale: 1; Flux lumineux: 1380 lm; Note d'identification: 600_ELECTRICITE C.FORTS; Taille du symbole de la source d'éclairage: 0.6096 m; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6884486 | Luminaires | 604_REGLETTE ETANCHE 120CM | 0 | 2021_015 | yes | yes | Modèle Revit lié : B02_DC_STR.rvt | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6879838 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.57 m; Niveau de nomenclature: S1; Cotes - Volume: 0.156244 m3; Surface: 1.11579 m2; Electricité - Charges - Panneau: TD1-Q36-BD3; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-36 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.6; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Hémisphérique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 47 lx; Intensité lumineuse: 439 cd; Efficacité: 149 lm/W; Puissance: 9 W; Facteur de perte de luminosité totale: 1; Flux lumineux: 1380 lm; Note d'identification: 600_ELECTRICITE C.FORTS; Taille du symbole de la source d'éclairage: 0.6096 m; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6884494 | Luminaires | 604_REGLETTE ETANCHE 120CM | 0 | 2021_015 | yes | yes | Modèle Revit lié : B02_DC_STR.rvt | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6879838 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.57 m; Niveau de nomenclature: S1; Cotes - Volume: 0.156244 m3; Surface: 1.11579 m2; Electricité - Charges - Panneau: TD1-Q36-BD3; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-36 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.6; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Hémisphérique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 47 lx; Intensité lumineuse: 439 cd; Efficacité: 149 lm/W; Puissance: 9 W; Facteur de perte de luminosité totale: 1; Flux lumineux: 1380 lm; Note d'identification: 600_ELECTRICITE C.FORTS; Taille du symbole de la source d'éclairage: 0.6096 m; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6884502 | Luminaires | 604_REGLETTE ETANCHE 120CM | 0 | 2021_015 | yes | yes | Modèle Revit lié : B02_DC_STR.rvt | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6879838 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.57 m; Niveau de nomenclature: S1; Cotes - Volume: 0.156244 m3; Surface: 1.11579 m2; Electricité - Charges - Panneau: TD1-Q36-BD3; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-36 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.6; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Hémisphérique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 47 lx; Intensité lumineuse: 439 cd; Efficacité: 149 lm/W; Puissance: 9 W; Facteur de perte de luminosité totale: 1; Flux lumineux: 1380 lm; Note d'identification: 600_ELECTRICITE C.FORTS; Taille du symbole de la source d'éclairage: 0.6096 m; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6885921 | Luminaires | 604_REGLETTE ETANCHE 120CM | 0 | 2021_015 | yes | yes | Modèle Revit lié : B02_DC_STR.rvt | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6879838 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.57 m; Niveau de nomenclature: S1; Cotes - Volume: 0.156244 m3; Surface: 1.11579 m2; Electricité - Charges - Panneau: TD1-Q36-BD5; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-36 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.7; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Hémisphérique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 47 lx; Intensité lumineuse: 439 cd; Efficacité: 149 lm/W; Puissance: 9 W; Facteur de perte de luminosité totale: 1; Flux lumineux: 1380 lm; Note d'identification: 600_ELECTRICITE C.FORTS; Taille du symbole de la source d'éclairage: 0.6096 m; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6885922 | Luminaires | 604_REGLETTE ETANCHE 120CM | 0 | 2021_015 | yes | yes | Modèle Revit lié : B02_DC_STR.rvt | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6879838 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.57 m; Niveau de nomenclature: S1; Cotes - Volume: 0.156244 m3; Surface: 1.11579 m2; Electricité - Charges - Panneau: TD1-Q36-BD5; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-36 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.7; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Hémisphérique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 47 lx; Intensité lumineuse: 439 cd; Efficacité: 149 lm/W; Puissance: 9 W; Facteur de perte de luminosité totale: 1; Flux lumineux: 1380 lm; Note d'identification: 600_ELECTRICITE C.FORTS; Taille du symbole de la source d'éclairage: 0.6096 m; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6915179 | Luminaires | 604_REGLETTE ETANCHE 120CM | 0 | 2021_015 | yes | yes | Modèle Revit lié : B02_DC_STR.rvt | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6879838 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_REGLETTE ETANCHE 120CM | 604_REGLETTE ETANCHE 120CM | Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.57 m; Niveau de nomenclature: S1; Cotes - Volume: 0.156244 m3; Surface: 1.11579 m2; Electricité - Charges - Panneau: TD1-Q36-BD2; Numero de circuit: 2; Electricité - Circuit - Données électriques: 230 V/1-36 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.2; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Hémisphérique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 47 lx; Intensité lumineuse: 439 cd; Efficacité: 149 lm/W; Puissance: 9 W; Facteur de perte de luminosité totale: 1; Flux lumineux: 1380 lm; Note d'identification: 600_ELECTRICITE C.FORTS; Taille du symbole de la source d'éclairage: 0.6096 m; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
Installations électriques | Category | Installations électriques | S1
603_DETECTEUR PD4-M-1C-C-PS | Family | 603_DETECTEUR PD4-M-1C-C-PS | S1
CATALOGUE DE TYPE | Type | CATALOGUE DE TYPE | S1
603_DETECTEUR PD4-M-1C-C-PS | CATALOGUE DE TYPE | 603_DETECTEUR PD4-M-1C-C-PS | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6915222 | Installations électriques | CATALOGUE DE TYPE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5044805 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_DETECTEUR PD4-M-1C-C-PS | 603_DETECTEUR PD4-M-1C-C-PS | Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Identifiant: 7; Contraintes - Niveau: S1; Élévation par rapport au niveau: 2.47 m; Niveau de nomenclature: S1; ZZZ_X_Length: 0.0505 m; ZZZ_Y_Length: 0.0505 m; ZZZ_Suspension_height_02_Length: 0 m; ZZZ_Logo LOD400_YesNo: no; ZZZ_Logo LOD200_YesNo: yes; ZZZ_Suspension_height_03_Length: 0 m; ZZZ_SOg_3D_gen_YesNo: no; ZZZ_Suspension_height_01_Length: 0 m; ZZZ_Detection zone_3D_type_FamilyType_Lighting Devices: standard; Cotes - Volume: 0.00946941 m3; Surface: 0.468618 m2; Electricité - Charges - Panneau: TD1-Q36-BD2; Numero de circuit: 2; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.2; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: MOVEMENTSENSOR; Fabricant: B.E.G.; Modèle: capteur de mouvement; URL: -; Description: capteur de mouvement; Exporter le type au format IFC sous: IfcAirTerminalType; Couleur: -; Code d'assemblage: 62.60.10; IfcExportAs: IfcAirTerminalType; IfcExportType: MOVEMENTSENSOR; RSen_C_content_date_issue: 29/09/2023; ZZZ_Cut out_X_Length: 0 m; ZZZ_Logo_Z_Length: 0 m; ZZZ_Height_Width_Length: 0.076 m; ZZZ_Width_Length: 0.101 m; ZZZ_Suspension_YesNo: no; ZZZ_Cut out_Y_Length: 0 m; ZZZ_Const_06_Length: 0 m; ZZZ_Width_Height_Length: 0.101 m; ZZZ_Recessed_YesNo: no; ZZZ_Cut out_length_Length: 0 m; ZZZ_Const_05_Length: 0 m; ZZZ_Parallel wall mounted_YesNo: no; ZZZ_Const_04_Length: 0 m; ZZZ_Logo_plane_Integer: 2; ZZZ_Detection zone_rotation_Angle: 0 deg; ZZZ_Mounted_ceiling_YesNo: no; ZZZ_Logo_Y_Length: 0 m; ZZZ_Cut out_length__Length: 0.001 m; ZZZ_Detection zone_X_Length: 0 m; ZZZ_Cut out_height_Length: 0 m; ZZZ_Cut out_width__Length: 0.001 m; ZZZ_Pendant - vertical mounted_YesNo: no; ZZZ_Logo_X_Length: 0 m; ZZZ_Zones_plane_Integer: 2; ZZZ_Cut out_width_Length: 0 m; ZZZ_Const_03_Length: 0 m; ZZZ_Displacement_Y_Length: 0 m; ZZZ_Height negative_Length: -0.076 m; ZZZ_Height_Length: 0.076 m; ZZZ_Detection zone_plane_Integer: 1; ZZZ_Detection zone_Z_Length: 0 m; ZZZ_Pendant - horizontal mounted_YesNo: no; ZZZ_Logo_Rotation about axis_Angle: 180 deg; ZZZ_Cut out_diameter_Length: 0 m; ZZZ_Surface mounted_YesNo: yes; ZZZ_IP_YesNo: no; ZZZ_Recess depth_Length: 0 m; ZZZ_Mounted_wall_YesNo: yes; ZZZ_Angled wall mounted_YesNo: no; ZZZ_Cut out_radius_Length: 0.001 m; ZZZ_Detection zone_Y_Length: 0 m; ZZZ_Cut out_height negative_Length: -0.002 m; ZZZ_Const_01_Length: 0 m; ZZZ_Length_Length: 0.101 m; ZZZ_Const_02_Length: 0 m; ZZZ_Placeholder for SOg_FamilyType_Lighting Devices: aucun; ZZZ_Detection zone_3D_standard_FamilyType_Lighting Devices: standard; ZZZ_Visualized connectors_FamilyType_Generic Models: standard; ZZZ_Detection zone_3D_none_FamilyType_Lighting Devices: standard; ZZZ_Bounding Box_FamilyType_Lighting Devices: standard; ZZZ_Annotation_FamilyType_Generic Annotations: standard; ZZZ_V Component_02_X_Length: 0 m; ZZZ_V Component_01_width_Length: 0 m; ZZZ_V E_c01_Z_Length: 0 m; ZZZ_V Component_03_width_Length: 0 m; ZZZ_V Clearance zone_bottom_Length: 0 m; ZZZ_V Component_03_Y_Length: 0 m; ZZZ_V Component_01_Z_Length: 0 m; ZZZ_V Component_03_length_Length: 0 m; ZZZ_V Component_03_height_Length: 0 m; ZZZ_V Clearance zone_top_Length: 0 m; ZZZ_V Light sensor_YesNo: no; ZZZ_V E_c01_Y_Length: 0 m; ZZZ_V Detection range at height_Length: 2.5 m; ZZZ_V Detection range_02_max height_Length: 5 m; ZZZ_V Suspension_plane_Integer: 2; ZZZ_V Component_01_plane_Integer: 1; ZZZ_V Component_03_diameter_Length: 0 m; ZZZ_V SOg_plane_Integer: 2; ZZZ_V Component_02_width_Length: 0 m; ZZZ_V Detection zone_03_material_Material: RSfr_x_rgb 000 128 000 T80 vert_gen; ZZZ_V Clearance zone_material_Material: RSfr_x_rgb 255 128 128 T80 rouge_gen; ZZZ_V Detection angle_Angle: 360 deg; ZZZ_V Detection range_01_Length: 40 m; ZZZ_V Component_02_Z_Length: 0 m; ZZZ_V SOg_X_Length: 0 m; ZZZ_V Component_03_Z_Length: 0 m; ZZZ_V Clearance zone_right_Length: 0 m; ZZZ_V SOg_Y_Length: 0 m; ZZZ_V Component_01_length_Length: 0 m; ZZZ_V Ventilation control_YesNo: no; ZZZ_V Component_03_plane_Integer: 1; ZZZ_V Component_01_height_Length: 0.076 m; ZZZ_V Suspension_Y_Length: 0 m; ZZZ_V Component_02_Y_Length: 0 m; ZZZ_V IP_Integer: 0; ZZZ_V Component_01_X_Length: 0 m; ZZZ_V E_c01_plane_Integer: 1; ZZZ_V Detection range_01_max height_Length: 5 m; ZZZ_V Component_02_length_Length: 0 m; ZZZ_V Detection range_03_max height_Length: 3.5 m; ZZZ_V Component_02_height_Length: 0 m; ZZZ_V E_c01_X_Length: 0 m; ZZZ_V Clearance zone_back_Length: 0 m; ZZZ_V Clearance zone_front_Length: 0 m; ZZZ_V Detection range_03_Length: 5 m; ZZZ_V Component_03_X_Length: 0 m; ZZZ_V Component_02_description_Text: -; ZZZ_V Detection range_02_Length: 7 m; ZZZ_V Component_02_diameter_Length: 0 m; ZZZ_V SOg_rotation_Angle: 0 deg; ZZZ_V Suspension_offset_Length: 0 m; ZZZ_V Suspension_width_Length: 0 m; ZZZ_V Component_01_diameter_Length: 0.101 m; ZZZ_V Dimmer_YesNo: no; ZZZ_V Component_03_description_Text: -; ZZZ_V SOg_Z_Length: 0 m; ZZZ_V Suspension_X_Length: 0 m; ZZZ_V Component_02_plane_Integer: 2; ZZZ_V Suspension_min_Length: 0 m; ZZZ_V Detection zone_02_material_Material: RSfr_x_rgb 000 128 255 T80 bleu_gen; ZZZ_V Component_01_description_Text: détecteur; ZZZ_V Suspension_max_Length: 0 m; ZZZ_V Component_01_Y_Length: 0 m; ZZZ_V Detection zone_01_material_Material: RSfr_x_rgb 255 128 128 T80 rouge_gen; ZZZ_V Clearance zone_left_Length: 0 m; ZZZ_V Suspension_length_Length: 0 m; ZZZ_V Suspension_type_FamilyType_Lighting Devices: aucun_gen; RSfr_C_type: capteur de mouvement; RSfr_C_content_version: 1.0.0; RSfr_C_revit_version: 2020; TBQfr_C_licence_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; RSfr_C_code_gtin: -; RSfr_C_type_commentaires: capteur de mouvement; RSfr_C_code_ETIM_url: http://prod.etim-international.com/; RSfr_C_content_date_modifié: 29/09/2023; TBQfr_C_code_produit: -; RSfr_C_content_fournisseur: B.E.G.; RSfr_C_content_créateur: © ThorbiQ; RSfr_C_description: capteur de mouvement; RSfr_C_code_article: -; TBQfr_C_IFC_version: 2x3; RSfr_C_code_classe_de_produit: -; RSfr_C_modèle: capteur de mouvement; TBQfr_C_licence: Creative Commons Attribution NoDerivs (CC-ND); RSfr_C_largeur: 0 m; RSfr_C_hauteur: 0.076 m; TBQfr_C_SOg_LD_2D: aucun; TBQfr_C_accessoires_EE_02: aucun_gen; TBQfr_C_accessoires_EE_05: aucun_gen; RSfr_E_c01_puissance_apparente: 0 VA; RSfr_E_c01_nombre_de_pôles: 1; TBQfr_C_accessoires_EE_03: aucun_gen; RSfr_C_longueur: 0 m; RSfr_E_c01_tension: 230 V; TBQfr_E_c01_oui_non: yes; TBQfr_C_SOg_LD_3D: aucun; TBQfr_C_accessoires_EE_04: aucun_gen; RSfr_C_diamètre: 0.101 m; RSfr_E_c01_sous_indice_de_charge_moteur: no; TBQfr_C_accessoire_01_description: -; RSfr_E_c01_description: -; TBQfr_E_c01_type_de_système: -; TBQ_I BaseKeynote: 62.60.10; TBQ_I Domaine de saisie des données: -; TBQ_I Maître: yes; TBQ_I Esclave: no; TBQ_I Type de sortie: -; Scénario: -; Dimensions du bloc d'alimentation externe: -; Puissance interne W: -; Absorption de courant mA: -; Réglages: -; Surface contrôlée approche tangentielle m² à une hauteur de montage de 2,5 m: -; Hauteur de montage Min. m: -; Hauteur de montage Max. m: -; Hauteur de montage Recommandé m: -; Mesurage du lumière: -; Évaluation de la température: -; Boîtier: -; Longeur de cable cm: -; KNX Nombre de capteurs de luminosité: -; KNX Nombre de capteurs PIR: -; KNX TP 256: -; Canal 01: -; Canal 01 Puissance: -; Canal 01 Lumière d’orientation: -; Canal 01 Nachtlicht: -; Canal 02: -; Canal 02 Puissance: -; Canal 02 Durée de temporisation: -; Canal 02 Lumière d’orientation: -; Canal 02 Seuil d´enchlenchement Lux: -; Détecteur Largeur en mm: -; Détecteur Hauteur en mm: -; Détecteur Profondeur en mm: -; Graphismes - ZZZ_V Position annotation x_Integer: 0; ZZZ_V Position annotation y_Integer: 0; ZZZ_V Displacement annotation y_Length: 0 m; ZZZ_V Displacement annotation x_Length: 0 m; TBQfr_C_zone_libre: no; TBQfr_C_portée_02_description: Frontale; TBQfr_C_portée_01_description: Transversale; TBQfr_C_logo: yes; TBQfr_C_portée_01: no; TBQfr_C_portée_02: no; TBQfr_C_portée_03_description: Activité assise; TBQfr_C_portée_03: no; Construction - ZZZ_V Suspension_height_Length: 0 m; TBQfr_C_alignement: Centre; TBQfr_C_GOg: yes; TBQfr_C_accessoires_EE_01: aucun_gen; TBQfr_C_alignement_index: 0; TBQfr_C_SOg: no; TBQfr_C_hauteur_de_montage: 2.5 m; Electrique - TBQfr_E_facteur_de_puissance: 1; TBQfr_E_c01_facteur_de_puissance: 1; RSfr_E_c01_indice_de_charge: Other
