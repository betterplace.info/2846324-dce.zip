Properties of the parts of a building model (IFC4), part 28 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 5554108 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.24; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Instance | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1536501 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Autre - Nom de la famille: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Classe Etim: EC002948 support pour installation domotique modulaire; Données d'identification - Nom du type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.145 m; Hauteur: 0.077 m; Profondeur: 0.0157 m; Electrique - Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Family | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Type | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 5554109 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.24; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Instance | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1536500 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Autre - Nom de la famille: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Classe Etim: EC000007 Cadre de finition; Données d'identification - Nom du type: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.153 m; Hauteur: 0.082 m; Profondeur: 0.009 m; Electrique - Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Family | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Type | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 5554110 | Installations électriques | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | 0 | 2021_015 | yes | yes | Niveau : N0 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 715042 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q24; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0; Cotes - Volume: 0.0000955133 m3; Electricité - Charges - Panneau: TD1-Q24-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.24; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.036 m; Hauteur: 0.045 m; Classe Etim: EC001590 Appareillage domestique; Réf legrand: LG-077011L; EAN: 3414971575165; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077011L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 31; IK: 04; Courant nominal: 10 A; Tension nominale: 250 V; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Instance | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 715042 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Autre - Nom de la famille: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Classe Etim: EC001590 Appareillage domestique; Données d'identification - Nom du type: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Note d'identification: 600_ELECTRICITE C.FORTS; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.045 m; Hauteur: 0.045 m; Profondeur: 0.036 m; Electrique - Réf legrand: LG-077011L; EAN: 3414971575165; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077011L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 31; IK: 04; Courant nominal: 10 A; Tension nominale: 250 V
Legrand_Mosaic_vide | Family | Legrand_Mosaic_vide | N0
Legrand_Mosaic_vide | Type | Legrand_Mosaic_vide | N0
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 5554111 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 5554113 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0; Se déplace avec les éléments voisins: no
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Family | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Type | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 5554112 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q22; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q22-BD4; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.24; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Instance | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 906741 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Autre - Nom de la famille: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Classe Etim: EC000125 Prise de courant; Données d'identification - Nom du type: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Note d'identification: 600_ELECTRICITE C.FORTS; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.045 m; Hauteur: 0.045 m; Profondeur: 0.038 m; Electrique - Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB
603_2POSTES_CLS_PUI_LEGRAND | Family | 603_2POSTES_CLS_PUI_LEGRAND | N0
PC 2P+T 230V X2 | Type | PC 2P+T 230V X2 | N0
603_2POSTES_CLS_PUI_LEGRAND | PC 2P+T 230V X2 | 603_2POSTES_CLS_PUI_LEGRAND | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 5798392 | Installations électriques | PC 2P+T 230V X2 | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1662294 | 0.3 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_CLS_PUI_LEGRAND | 603_2POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0; Élévation par rapport au niveau: 1.2 m; Niveau de nomenclature: N0; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042; Plate: Legrand_Mosaic_plaque_4_mod_blanc_078814L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC+T 230V X2: yes; PC 2P+T 230V + RJ45: no; Visibilité - Interconnexions 2PC: yes
603_2POSTES_CLS_PUI_LEGRAND | PC 2P+T 230V X2 | 603_2POSTES_CLS_PUI_LEGRAND | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 5798403 | Installations électriques | PC 2P+T 230V X2 | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1662294 | 0.3 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_CLS_PUI_LEGRAND | 603_2POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0; Élévation par rapport au niveau: 1.2 m; Niveau de nomenclature: N0; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042; Plate: Legrand_Mosaic_plaque_4_mod_blanc_078814L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC+T 230V X2: yes; PC 2P+T 230V + RJ45: no; Visibilité - Interconnexions 2PC: yes
603_2POSTES_CLS_PUI_LEGRAND | PC 2P+T 230V X2 | 603_2POSTES_CLS_PUI_LEGRAND | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 5798426 | Installations électriques | PC 2P+T 230V X2 | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1662294 | 0.3 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_CLS_PUI_LEGRAND | 603_2POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0; Élévation par rapport au niveau: 1.2 m; Niveau de nomenclature: N0; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042; Plate: Legrand_Mosaic_plaque_4_mod_blanc_078814L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC+T 230V X2: yes; PC 2P+T 230V + RJ45: no; Visibilité - Interconnexions 2PC: yes
<Séparation d'espace> | Category | <Séparation d'espace> | N0

# IfcBuildingElementProxy (257)
In: B02_ELE.rvt
Elément - Fichier source: B02_ELE.rvt
Informations sur le partage du travail des éléments - État des mises à jour des modèles: CurrentWithCentral; État du retrait: NotOwned; Créateur: boulanger-mathe; Dernière modification par: boulanger-mathe
Name | Type | Elément, Nom | Calque | Value = Authoring Tool Id | Autre, Catégorie | Nom de la famille | Données d'identification, Sous-projet | Nom du type | Elévation par défaut (m) | Exporter le type au format IFC
11 x 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Instance | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | 1546975 | Installations électriques | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR SA + PC 2P+T 230V | 1.0645 | 0 | Autre - VV: no; SA: yes; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no; Cotes - Décalage saillie: 0 m; Electrique - Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide
5 x 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Instance | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | 4778033 | Installations électriques | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | PC 2P+T 230V + RJ45_FTP CAT-6 | 1.0645 | 0 | Autre - VV: no; SA: no; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: yes; Cotes - Décalage saillie: 0 m; Electrique - Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Instance | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | 6648994 | Installations électriques | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | PC 2P+T 230V + RJ45_FTP CAT-6 | 1.0645 | 0 | Autre - VV: no; SA: no; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: yes; Cotes - Décalage saillie: 0 m; Electrique - Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Instance | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | 1547111 | Installations électriques | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR VV + PC 2P+T 230V | 1.0645 | 0 | Autre - VV: yes; SA: no; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no; Cotes - Décalage saillie: 0 m; Electrique - Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide
179 x Legrand_Mosaic_vide | Instance | Legrand_Mosaic_vide | N0_FINI | 676772 | Installations électriques | Legrand_Mosaic_vide | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | 1 | 0
2 x Legrand_Mosaic_vide | Instance | Legrand_Mosaic_vide | N0_FINI | 4802751 | Installations électriques | Legrand_Mosaic_vide | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | 1 | 0
12 x 603_10POSTES_CLS_PUI_LEGRAND | Instance | 603_10POSTES_CLS_PUI_LEGRAND | N0_FINI | 6728498 | Installations électriques | 603_10POSTES_CLS_PUI_LEGRAND | Famille : Installations électriques : 603_10POSTES_CLS_PUI_LEGRAND | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 0 | 0 | Cotes - Décalage saillie: 0 m; Electrique - Flush mounting box: Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128; Plate: Legrand_Mosaic_plaque_2x10_mod_blanc_078828L; Support frame type: Legrand_Batibox_support_2X10_mod_080268; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 20: Legrand_Mosaic_vide
10 x 603_1POSTE_CLS_PUI_LEGRAND | Instance | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI | 916677 | Installations électriques | 603_1POSTE_CLS_PUI_LEGRAND | Famille : Installations électriques : 603_1POSTE_CLS_PUI_LEGRAND | PC 2P+T 230V_45° | 0.3 | 0 | Cotes - Décalage saillie: 0 m; Electrique - Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Plate: Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L; Support frame type: Legrand_Batibox_support_1_poste_2_mod_080251; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_vide; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; Autre - PC 2P+T_45°_A_D_V: no; PC 2P+T_45°_A_D: no; PC_2P+T_45°_V: no; PC 2P+T_A: no; PC 2P+T_45°_A: yes
3 x 603_1POSTE_CLS_PUI_LEGRAND | Instance | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI | 916675 | Installations électriques | 603_1POSTE_CLS_PUI_LEGRAND | Famille : Installations électriques : 603_1POSTE_CLS_PUI_LEGRAND | PC 2P+T 230V | 0 | 0 | Cotes - Décalage saillie: 0 m; Electrique - Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Plate: Legrand_Mosaic_plaque_2_mod_blanc_078802L; Support frame type: Legrand_Batibox_support_1_poste_2_mod_080251; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_vide; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; Autre - PC 2P+T_45°_A_D_V: no; PC 2P+T_45°_A_D: no; PC_2P+T_45°_V: no; PC 2P+T_A: yes; PC 2P+T_45°_A: no
603_4POSTES_CLS_PUI_LEGRAND | Instance | 603_4POSTES_CLS_PUI_LEGRAND | N0_FINI | 5607346 | Installations électriques | 603_4POSTES_CLS_PUI_LEGRAND | Famille : Installations électriques : 603_4POSTES_CLS_PUI_LEGRAND | PC 2P+T 230V_45° X2 + RJ45_FTP-CAT6 X2 | 0.3 | 0 | Cotes - Décalage saillie: 0 m; Electrique - Flush mounting box: Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043; Plate: Legrand_Mosaic_plaque_8_mod_blanc_078818L; Support frame type: Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; Autre - PC 2P+T_45°_A_D + RJ45 X3: no; PC 2P+T_45°_A X2 + RJ45 X2: yes; PC 2P+T_45°_A X3 + RJ45: no; PC 2P+T_45°_A_D X4: no; PC 2P+T_45°_A + PC 2P+T_45°_A_D X3: no; PC 2P+T_45°_A X2 + PC 2P+T_45°_A_D X2: no; PC 2P+T_45°_A X3 + PC 2P+T_45°_A_D: no; PC 2P+T_45°_A X4: no; PC 2P+T_45°_A + PC 2P+T_45°_A_D + RJ45 X2: no; PC 2P+T_45°_A + PC 2P+T_45°_A_D X2 + RJ45: no; PC 2P+T_45°_A X2 + PC 2P+T_45°_A_D + RJ45: no; PC 2P+T_45°_A_D X2 + RJ45 X2: no; PC 2P+T_45°_A_D X3 + RJ45: no; PC 2P+T_45°_A + RJ45 X3: no
2 x 603_5POSTES_CLS_PUI_LEGRAND | Instance | 603_5POSTES_CLS_PUI_LEGRAND | N0_FINI | 6718433 | Installations électriques | 603_5POSTES_CLS_PUI_LEGRAND | Famille : Installations électriques : 603_5POSTES_CLS_PUI_LEGRAND | 603_5POSTES_CLS_PUI_LEGRAND | 0 | 0 | Cotes - Décalage saillie: 0 m; Electrique - Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_4_postes_8_10_mod_080044; Plate: Legrand_Mosaic_plaque_10_mod_blanc_078810L; Support frame type: Legrand_Batibox_support_4_postes_10_mod_080254; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide
Lignes de modèle | Lignes de modèle | Lignes de modèle | S1 | 6705331 | Lignes: <Séparation d'espace> |  | 2021_015 | Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Cotes - Longueur: 1.02408 m; Reste concentrique: yes; Contraintes - Se déplace avec les éléments voisins: no; Graphismes - Ligne de détail: no; Marque centrale visible: no
4 x 603_3POSTES_VERTICAUX_PLEXO | Instance | 603_3POSTES_VERTICAUX_PLEXO | S1 | 7091303 | Installations électriques | 603_3POSTES_VERTICAUX_PLEXO | Famille : Installations électriques : 603_3POSTES_VERTICAUX_PLEXO | 603_3POSTES_VERTICAUX_PLEXO | 0.0011 | 0 | Electrique - Module 1: Legrand_Plexo_composable_poussoir_NO_gris_069540L; Module 2: Legrand_Plexo_composable_prise_FB_gris_069551L; Module 3: Legrand_Plexo_composable_prise_FB_gris_069551L; Type de boite d'encastrement: Legrand_Plexo_vide; Boite d'encastrement: no; Type de boitier ou de support: Legrand_Plexo_boitier_vertical_3_postes_gris_069680L; Autre - CALC_DS: 0.0512 m; Données d'identification - Titre OmniClass: Electric Power and Lighting; Numéro OmniClass: 23.80.00.00
5 x Legrand_Plexo_vide | Instance | Legrand_Plexo_vide | S1 | 7081427 | Installations électriques | Legrand_Plexo_vide | Famille : Installations électriques : Legrand_Plexo_vide | Legrand_Plexo_vide | 1.2192 | 0
603_1POSTE_PLEXO | Instance | 603_1POSTE_PLEXO | S1 | 7099356 | Installations électriques | 603_1POSTE_PLEXO | Famille : Installations électriques : 603_1POSTE_PLEXO | PC 2P+T 230V | 0.0011 | 0 | Electrique - Module 1: Legrand_Plexo_composable_prise_FB_gris_069551L; Module 2: Legrand_Plexo_vide; Module 3: Legrand_Plexo_vide; Type de boite d'encastrement: Legrand_Plexo_vide; Boite d'encastrement: no; Type de boitier ou de support: Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L; Autre - CALC_DS: 0.0512 m; Données d'identification - Titre OmniClass: Electric Power and Lighting; Numéro OmniClass: 23.80.00.00
10 x Legrand_Mosaic_vide | Instance | Legrand_Mosaic_vide | <NoLevel> | 676772 | Installations électriques | Legrand_Mosaic_vide | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | 1 | 0
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Instance | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0 | 1547111 | Installations électriques | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR VV + PC 2P+T 230V | 1.0645 | 0 | Autre - VV: yes; SA: no; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no; Cotes - Décalage saillie: 0 m; Electrique - Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide
2 x Legrand_Mosaic_vide | Instance | Legrand_Mosaic_vide | N0 | 676772 | Installations électriques | Legrand_Mosaic_vide | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | 1 | 0
3 x 603_2POSTES_CLS_PUI_LEGRAND | Instance | 603_2POSTES_CLS_PUI_LEGRAND | N0 | 1662294 | Installations électriques | 603_2POSTES_CLS_PUI_LEGRAND | Famille : Installations électriques : 603_2POSTES_CLS_PUI_LEGRAND | PC 2P+T 230V X2 | 0.3 | 0 | Cotes - Décalage saillie: 0 m; Electrique - Flush mounting box: Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042; Plate: Legrand_Mosaic_plaque_4_mod_blanc_078814L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; Autre - PC+T 230V X2: yes; PC 2P+T 230V + RJ45: no
Lignes de modèle | Lignes de modèle | Lignes de modèle | N0 | 6285606 | Lignes: <Séparation d'espace> |  | 2021_015 | Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Cotes - Longueur: 6.047 m; Contraintes - Se déplace avec les éléments voisins: no; Graphismes - Ligne de détail: no
Lignes de modèle | Lignes de modèle | Lignes de modèle | N0 | 6285832 | Lignes: <Séparation d'espace> |  | 2021_015 | Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Cotes - Longueur: 8.78289 m; Contraintes - Se déplace avec les éléments voisins: no; Graphismes - Ligne de détail: no
Lignes de modèle | Lignes de modèle | Lignes de modèle | N0 | 6285917 | Lignes: <Séparation d'espace> |  | 2021_015 | Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Cotes - Longueur: 1.916 m; Contraintes - Se déplace avec les éléments voisins: no; Graphismes - Ligne de détail: no
