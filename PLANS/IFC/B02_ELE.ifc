Properties of the parts of a building model (IFC4), part 13 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755859 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755861 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755863 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755865 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755867 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755869 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755871 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755873 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755875 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755877 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755879 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755881 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755883 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755885 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755887 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755889 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755891 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755893 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755895 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755897 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755899 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755901 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755903 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755905 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755907 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755909 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755911 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755913 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755915 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755917 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755919 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755921 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755923 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755925 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755927 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755929 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755931 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755933 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755935 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755937 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755939 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755941 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755943 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755945 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755947 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755949 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755951 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755953 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755955 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755957 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755959 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755961 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755963 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755965 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755967 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755969 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755971 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755973 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755975 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6769491 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6769493 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6769495 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6769497 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6769499 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6769500 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6782709 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6782711 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6782713 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6782715 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6782717 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6782718 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6842045 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Family | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Type | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750555 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q20; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q20-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
15 x Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Instance | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 906741 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Autre - Nom de la famille: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Classe Etim: EC000125 Prise de courant; Données d'identification - Nom du type: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Note d'identification: 600_ELECTRICITE C.FORTS; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.045 m; Hauteur: 0.045 m; Profondeur: 0.038 m; Electrique - Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750576 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q20; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q20-BD2; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750675 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q20; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q20-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750719 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q21; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q21-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750766 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q21; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q21-BD2; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.13; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750812 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q21; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q21-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.14; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750855 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q20; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q20-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.22; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751015 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q21; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q21-BD3; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751072 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q21; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q21-BD4; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5416223 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q21; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q21-BD3; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5525172 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q20; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q20-BD1; Numero de circuit: 3; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
