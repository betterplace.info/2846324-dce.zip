Properties of the parts of a building model (IFC4), part 6 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158379 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5535464 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.6 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411673 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 3; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 36 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 0 A; Courant de Phase B: 0 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 0 A; Intensité installée totale: 0 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 36 VA; Puissance apparente installée totale: 36 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 36 VA; Puissance apparente - Phase A: 0 VA; Puissance apparente requise Autre: 36 VA; Puissance apparente connectée Autre: 36 VA; Autre - Intensité utilisée estimée: 0 A; Autre - Intensité installée: 0 A; Autre - Coefficient d'utilisation: 100.00%; Other Estimated Demand: 0 VA; Other Connected: 0 VA; Other Estimated Demand Current: 0 A; Other Connected Current: 0 A; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1-Q23-BD7; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Nom du panneau: TD1-Q23-BD8; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: ECL; Texte - TEXTE 3D: TD1-Q23-BD8
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158394 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5535490 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.6 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411372 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 3; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 54 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 0 A; Courant de Phase B: 0 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 0 A; Intensité installée totale: 0 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 54 VA; Puissance apparente installée totale: 54 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 54 VA; Puissance apparente - Phase A: 0 VA; Puissance apparente requise Autre: 54 VA; Puissance apparente connectée Autre: 54 VA; Autre - Intensité utilisée estimée: 0 A; Autre - Intensité installée: 0 A; Autre - Coefficient d'utilisation: 100.00%; Other Estimated Demand: 0 VA; Other Connected: 0 VA; Other Estimated Demand Current: 0 A; Other Connected Current: 0 A; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1-Q23-BD6; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Nom du panneau: TD1-Q23-BD7; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: ECL; Texte - TEXTE 3D: TD1-Q23-BD7
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158391 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5536316 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.6 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411623 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 4; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 72 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 0 A; Courant de Phase B: 0 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 0 A; Intensité installée totale: 0 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 72 VA; Puissance apparente installée totale: 72 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 72 VA; Puissance apparente - Phase A: 0 VA; Puissance apparente requise Autre: 72 VA; Puissance apparente connectée Autre: 72 VA; Autre - Intensité utilisée estimée: 0 A; Autre - Intensité installée: 0 A; Autre - Coefficient d'utilisation: 100.00%; Other Estimated Demand: 0 VA; Other Connected: 0 VA; Other Estimated Demand Current: 0 A; Other Connected Current: 0 A; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1-Q23-BD3; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Nom du panneau: TD1-Q23-BD6; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: ECL; Texte - TEXTE 3D: TD1-Q23-BD6
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158388 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5538682 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | 602_CHASSIS 400V : TD1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.7 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.041129 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 23; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 3 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 650 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 0 A; Courant de Phase B: 3 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 3 A; Intensité installée totale: 3 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 650 VA; Puissance apparente installée totale: 650 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 650 VA; Puissance apparente - Phase A: 0 VA; Puissance apparente requise Autre: 650 VA; Puissance apparente connectée Autre: 650 VA; Autre - Intensité utilisée estimée: 3 A; Autre - Intensité installée: 3 A; Autre - Coefficient d'utilisation: 100.00%; Other Estimated Demand: 0 VA; Other Connected: 0 VA; Other Estimated Demand Current: 0 A; Other Connected Current: 0 A; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Nom du panneau: TD1-Q23-BD1; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: ECL; Texte - TEXTE 3D: TD1-Q23-BD1
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158373 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5542028 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | Chemin de câbles avec raccords : Chemin de câbles à base pleine | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q22; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.5 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411617 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 2; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 5 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 1140 VA; Courant de Phase C: 0 A; Courant de Phase B: 0 A; Courant de Phase A: 5 A; Intensité requise estimée totale: 5 A; Intensité installée totale: 5 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 1140 VA; Puissance apparente installée totale: 1140 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 1140 VA; Puissance apparente requise Autre: 1140 VA; Puissance apparente connectée Autre: 1140 VA; Autre - Intensité utilisée estimée: 5 A; Autre - Intensité installée: 5 A; Autre - Coefficient d'utilisation: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1-Q22-BD1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Nom du panneau: TD1-Q22-BD2; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: PC 230N; Texte - TEXTE 3D: TD1-Q22-BD2
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158364 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5550743 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | Chemin de câbles avec raccords : Chemin de câbles à base pleine | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q24; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.5 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411321 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 24; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 1 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 320 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 1 A; Courant de Phase B: 0 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 1 A; Intensité installée totale: 1 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 320 VA; Puissance apparente installée totale: 320 VA; Puissance apparente - Phase C: 320 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 0 VA; Puissance apparente requise Autre: 320 VA; Puissance apparente connectée Autre: 320 VA; Autre - Intensité utilisée estimée: 1 A; Autre - Intensité installée: 1 A; Autre - Coefficient d'utilisation: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Nom du panneau: TD1-Q24-BD1; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: ECL; Texte - TEXTE 3D: TD1-Q24-BD1
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158397 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5552427 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q24; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.5 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411549 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 2; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 1 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 120 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 1 A; Courant de Phase B: 0 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 1 A; Intensité installée totale: 1 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 120 VA; Puissance apparente installée totale: 120 VA; Puissance apparente - Phase C: 120 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 0 VA; Puissance apparente requise Autre: 120 VA; Puissance apparente connectée Autre: 120 VA; Autre - Intensité utilisée estimée: 1 A; Autre - Intensité installée: 1 A; Autre - Coefficient d'utilisation: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1-Q24-BD2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Nom du panneau: TD1-Q24-BD3; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: ECL; Texte - TEXTE 3D: TD1-Q24-BD3
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158403 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5552445 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | Chemin de câbles avec raccords : Chemin de câbles à base pleine | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q24; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.5 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.041158 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 2; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 80 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 0 A; Courant de Phase B: 0 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 0 A; Intensité installée totale: 0 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 80 VA; Puissance apparente installée totale: 80 VA; Puissance apparente - Phase C: 80 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 0 VA; Puissance apparente requise Autre: 80 VA; Puissance apparente connectée Autre: 80 VA; Autre - Intensité utilisée estimée: 0 A; Autre - Intensité installée: 0 A; Autre - Coefficient d'utilisation: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1-Q24-BD3; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.24; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Emplacement: Pièce DC-N0-016; Nom du panneau: TD1-Q24-BD4; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: ECL; Texte - TEXTE 3D: TD1-Q24-BD4
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158406 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5553495 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | Chemin de câbles avec raccords : Chemin de câbles à base pleine | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q24; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.5 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411598 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 4; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 1 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 200 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 1 A; Courant de Phase B: 0 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 1 A; Intensité installée totale: 1 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 200 VA; Puissance apparente installée totale: 200 VA; Puissance apparente - Phase C: 200 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 0 VA; Puissance apparente requise Autre: 200 VA; Puissance apparente connectée Autre: 200 VA; Autre - Intensité utilisée estimée: 1 A; Autre - Intensité installée: 1 A; Autre - Coefficient d'utilisation: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1-Q24-BD1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Nom du panneau: TD1-Q24-BD2; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: ECL; Texte - TEXTE 3D: TD1-Q24-BD2
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158400 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
