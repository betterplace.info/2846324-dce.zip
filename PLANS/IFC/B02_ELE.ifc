Properties of the parts of a building model (IFC4), part 18 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
603_1POSTE_CLS_PUI_LEGRAND | PC 2P+T 230V_45° | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4818072 | Installations électriques | PC 2P+T 230V_45° | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 916677 | 0.3 | Installations électriques | 0 | Famille : Installations électriques : 603_1POSTE_CLS_PUI_LEGRAND | 603_1POSTE_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Plate: Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L; Support frame type: Legrand_Batibox_support_1_poste_2_mod_080251; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_vide; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC 2P+T_45°_A_D_V: no; PC 2P+T_45°_A_D: no; PC_2P+T_45°_V: no; PC 2P+T_A: no; PC 2P+T_45°_A: yes
603_1POSTE_CLS_PUI_LEGRAND | PC 2P+T 230V_45° | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4818782 | Installations électriques | PC 2P+T 230V_45° | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 916677 | 0.3 | Installations électriques | 0 | Famille : Installations électriques : 603_1POSTE_CLS_PUI_LEGRAND | 603_1POSTE_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Plate: Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L; Support frame type: Legrand_Batibox_support_1_poste_2_mod_080251; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_vide; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC 2P+T_45°_A_D_V: no; PC 2P+T_45°_A_D: no; PC_2P+T_45°_V: no; PC 2P+T_A: no; PC 2P+T_45°_A: yes
603_1POSTE_CLS_PUI_LEGRAND | PC 2P+T 230V_45° | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821128 | Installations électriques | PC 2P+T 230V_45° | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 916677 | 0.3 | Installations électriques | 0 | Famille : Installations électriques : 603_1POSTE_CLS_PUI_LEGRAND | 603_1POSTE_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Plate: Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L; Support frame type: Legrand_Batibox_support_1_poste_2_mod_080251; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_vide; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC 2P+T_45°_A_D_V: no; PC 2P+T_45°_A_D: no; PC_2P+T_45°_V: no; PC 2P+T_A: no; PC 2P+T_45°_A: yes
603_1POSTE_CLS_PUI_LEGRAND | PC 2P+T 230V_45° | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821746 | Installations électriques | PC 2P+T 230V_45° | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 916677 | 0.3 | Installations électriques | 0 | Famille : Installations électriques : 603_1POSTE_CLS_PUI_LEGRAND | 603_1POSTE_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Plate: Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L; Support frame type: Legrand_Batibox_support_1_poste_2_mod_080251; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_vide; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC 2P+T_45°_A_D_V: no; PC 2P+T_45°_A_D: no; PC_2P+T_45°_V: no; PC 2P+T_A: no; PC 2P+T_45°_A: yes
603_1POSTE_CLS_PUI_LEGRAND | PC 2P+T 230V_45° | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821834 | Installations électriques | PC 2P+T 230V_45° | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 916677 | 0.3 | Installations électriques | 0 | Famille : Installations électriques : 603_1POSTE_CLS_PUI_LEGRAND | 603_1POSTE_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Plate: Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L; Support frame type: Legrand_Batibox_support_1_poste_2_mod_080251; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_vide; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC 2P+T_45°_A_D_V: no; PC 2P+T_45°_A_D: no; PC_2P+T_45°_V: no; PC 2P+T_A: no; PC 2P+T_45°_A: yes
603_1POSTE_CLS_PUI_LEGRAND | PC 2P+T 230V_45° | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822442 | Installations électriques | PC 2P+T 230V_45° | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 916677 | 0.3 | Installations électriques | 0 | Famille : Installations électriques : 603_1POSTE_CLS_PUI_LEGRAND | 603_1POSTE_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Plate: Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L; Support frame type: Legrand_Batibox_support_1_poste_2_mod_080251; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_vide; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC 2P+T_45°_A_D_V: no; PC 2P+T_45°_A_D: no; PC_2P+T_45°_V: no; PC 2P+T_A: no; PC 2P+T_45°_A: yes
603_1POSTE_CLS_PUI_LEGRAND | PC 2P+T 230V_45° | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822562 | Installations électriques | PC 2P+T 230V_45° | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 916677 | 0.3 | Installations électriques | 0 | Famille : Installations électriques : 603_1POSTE_CLS_PUI_LEGRAND | 603_1POSTE_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Plate: Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L; Support frame type: Legrand_Batibox_support_1_poste_2_mod_080251; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_vide; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC 2P+T_45°_A_D_V: no; PC 2P+T_45°_A_D: no; PC_2P+T_45°_V: no; PC 2P+T_A: no; PC 2P+T_45°_A: yes
603_1POSTE_CLS_PUI_LEGRAND | PC 2P+T 230V_45° | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822988 | Installations électriques | PC 2P+T 230V_45° | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 916677 | 0.3 | Installations électriques | 0 | Famille : Installations électriques : 603_1POSTE_CLS_PUI_LEGRAND | 603_1POSTE_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Plate: Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L; Support frame type: Legrand_Batibox_support_1_poste_2_mod_080251; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_vide; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC 2P+T_45°_A_D_V: no; PC 2P+T_45°_A_D: no; PC_2P+T_45°_V: no; PC 2P+T_A: no; PC 2P+T_45°_A: yes
PC 2P+T 230V | Type | PC 2P+T 230V | N0_FINI
603_1POSTE_CLS_PUI_LEGRAND | PC 2P+T 230V | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5530035 | Installations électriques | PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 916675 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_1POSTE_CLS_PUI_LEGRAND | 603_1POSTE_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Plate: Legrand_Mosaic_plaque_2_mod_blanc_078802L; Support frame type: Legrand_Batibox_support_1_poste_2_mod_080251; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_vide; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC 2P+T_45°_A_D_V: no; PC 2P+T_45°_A_D: no; PC_2P+T_45°_V: no; PC 2P+T_A: yes; PC 2P+T_45°_A: no
603_1POSTE_CLS_PUI_LEGRAND | PC 2P+T 230V | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5532022 | Installations électriques | PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 916675 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_1POSTE_CLS_PUI_LEGRAND | 603_1POSTE_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Plate: Legrand_Mosaic_plaque_2_mod_blanc_078802L; Support frame type: Legrand_Batibox_support_1_poste_2_mod_080251; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_vide; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC 2P+T_45°_A_D_V: no; PC 2P+T_45°_A_D: no; PC_2P+T_45°_V: no; PC 2P+T_A: yes; PC 2P+T_45°_A: no
603_1POSTE_CLS_PUI_LEGRAND | PC 2P+T 230V | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6842041 | Installations électriques | PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 916675 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_1POSTE_CLS_PUI_LEGRAND | 603_1POSTE_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Plate: Legrand_Mosaic_plaque_2_mod_blanc_078802L; Support frame type: Legrand_Batibox_support_1_poste_2_mod_080251; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_vide; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC 2P+T_45°_A_D_V: no; PC 2P+T_45°_A_D: no; PC_2P+T_45°_V: no; PC 2P+T_A: yes; PC 2P+T_45°_A: no
Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Family | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI
Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Type | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI
Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4816917 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676768 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000126017 m3; Surface: 0.0129319 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Profondeur: 0.04 m; Hauteur: 0.071 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080041; EAN: 3245060800413; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080041-LEGRAND-1000.jpg
13 x Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Instance | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 676768 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Autre - Nom de la famille: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Classe Etim: EC002601 Boîte d'appareillage encastré; Données d'identification - Nom du type: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Diamètre: 0.067 m; Hauteur: 0.071 m; Profondeur: 0.04 m; Electrique - Réf legrand: LG-080041; EAN: 3245060800413; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080041-LEGRAND-1000.jpg; Fabricant: Legrand
Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4817318 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676768 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000126017 m3; Surface: 0.0129319 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Profondeur: 0.04 m; Hauteur: 0.071 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080041; EAN: 3245060800413; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080041-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4818073 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676768 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000126017 m3; Surface: 0.0129319 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Profondeur: 0.04 m; Hauteur: 0.071 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080041; EAN: 3245060800413; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080041-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4818783 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676768 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000126017 m3; Surface: 0.0129319 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Profondeur: 0.04 m; Hauteur: 0.071 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080041; EAN: 3245060800413; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080041-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821129 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676768 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000126017 m3; Surface: 0.0129319 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Profondeur: 0.04 m; Hauteur: 0.071 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080041; EAN: 3245060800413; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080041-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821747 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676768 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000126017 m3; Surface: 0.0129319 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Profondeur: 0.04 m; Hauteur: 0.071 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080041; EAN: 3245060800413; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080041-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821835 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676768 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000126017 m3; Surface: 0.0129319 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Profondeur: 0.04 m; Hauteur: 0.071 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080041; EAN: 3245060800413; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080041-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822443 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676768 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000126017 m3; Surface: 0.0129319 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Profondeur: 0.04 m; Hauteur: 0.071 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080041; EAN: 3245060800413; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080041-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822563 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676768 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000126017 m3; Surface: 0.0129319 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Profondeur: 0.04 m; Hauteur: 0.071 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080041; EAN: 3245060800413; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080041-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822989 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676768 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000126017 m3; Surface: 0.0129319 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Profondeur: 0.04 m; Hauteur: 0.071 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080041; EAN: 3245060800413; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080041-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5530036 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676768 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000126017 m3; Surface: 0.0129319 m2; Type de Revit - Fabricant: Legrand; Profondeur: 0.04 m; Hauteur: 0.071 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080041; EAN: 3245060800413; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080041-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5532023 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676768 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000126017 m3; Surface: 0.0129319 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.23; Type de Revit - Fabricant: Legrand; Profondeur: 0.04 m; Hauteur: 0.071 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080041; EAN: 3245060800413; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080041-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6842042 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676768 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041 | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000126017 m3; Surface: 0.0129319 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Fabricant: Legrand; Profondeur: 0.04 m; Hauteur: 0.071 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080041; EAN: 3245060800413; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080041-LEGRAND-1000.jpg
Legrand_Batibox_support_1_poste_2_mod_080251 | Family | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI
Legrand_Batibox_support_1_poste_2_mod_080251 | Type | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI
Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4816918 | Installations électriques | Legrand_Batibox_support_1_poste_2_mod_080251 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676767 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000107341 m3; Surface: 0.00428326 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.074 m; Profondeur: 0.0072 m; Hauteur: 0.074 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080251; EAN: 3245060802516; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080251-WEB-R.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal et vertical; Fixation: A vis
13 x Legrand_Batibox_support_1_poste_2_mod_080251 | Instance | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 676767 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Batibox_support_1_poste_2_mod_080251 | Autre - Nom de la famille: Legrand_Batibox_support_1_poste_2_mod_080251; Classe Etim: EC002948 support pour installation domotique modulaire; Données d'identification - Nom du type: Legrand_Batibox_support_1_poste_2_mod_080251; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.074 m; Hauteur: 0.074 m; Profondeur: 0.0072 m; Electrique - Réf legrand: LG-080251; EAN: 3245060802516; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080251-WEB-R.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4817319 | Installations électriques | Legrand_Batibox_support_1_poste_2_mod_080251 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676767 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000107341 m3; Surface: 0.00428326 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.074 m; Profondeur: 0.0072 m; Hauteur: 0.074 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080251; EAN: 3245060802516; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080251-WEB-R.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4818074 | Installations électriques | Legrand_Batibox_support_1_poste_2_mod_080251 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676767 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000107341 m3; Surface: 0.00428326 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.074 m; Profondeur: 0.0072 m; Hauteur: 0.074 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080251; EAN: 3245060802516; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080251-WEB-R.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4818784 | Installations électriques | Legrand_Batibox_support_1_poste_2_mod_080251 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676767 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000107341 m3; Surface: 0.00428326 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.074 m; Profondeur: 0.0072 m; Hauteur: 0.074 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080251; EAN: 3245060802516; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080251-WEB-R.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821130 | Installations électriques | Legrand_Batibox_support_1_poste_2_mod_080251 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676767 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000107341 m3; Surface: 0.00428326 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.074 m; Profondeur: 0.0072 m; Hauteur: 0.074 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080251; EAN: 3245060802516; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080251-WEB-R.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821748 | Installations électriques | Legrand_Batibox_support_1_poste_2_mod_080251 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676767 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000107341 m3; Surface: 0.00428326 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.074 m; Profondeur: 0.0072 m; Hauteur: 0.074 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080251; EAN: 3245060802516; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080251-WEB-R.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821836 | Installations électriques | Legrand_Batibox_support_1_poste_2_mod_080251 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676767 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000107341 m3; Surface: 0.00428326 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.074 m; Profondeur: 0.0072 m; Hauteur: 0.074 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080251; EAN: 3245060802516; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080251-WEB-R.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822444 | Installations électriques | Legrand_Batibox_support_1_poste_2_mod_080251 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676767 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000107341 m3; Surface: 0.00428326 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.074 m; Profondeur: 0.0072 m; Hauteur: 0.074 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080251; EAN: 3245060802516; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080251-WEB-R.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822564 | Installations électriques | Legrand_Batibox_support_1_poste_2_mod_080251 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676767 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000107341 m3; Surface: 0.00428326 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.074 m; Profondeur: 0.0072 m; Hauteur: 0.074 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080251; EAN: 3245060802516; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080251-WEB-R.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822990 | Installations électriques | Legrand_Batibox_support_1_poste_2_mod_080251 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676767 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000107341 m3; Surface: 0.00428326 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.074 m; Profondeur: 0.0072 m; Hauteur: 0.074 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080251; EAN: 3245060802516; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080251-WEB-R.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5530037 | Installations électriques | Legrand_Batibox_support_1_poste_2_mod_080251 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676767 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000107341 m3; Surface: 0.00428326 m2; Type de Revit - Fabricant: Legrand; Largeur: 0.074 m; Profondeur: 0.0072 m; Hauteur: 0.074 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080251; EAN: 3245060802516; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080251-WEB-R.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5532024 | Installations électriques | Legrand_Batibox_support_1_poste_2_mod_080251 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676767 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000107341 m3; Surface: 0.00428326 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.23; Type de Revit - Fabricant: Legrand; Largeur: 0.074 m; Profondeur: 0.0072 m; Hauteur: 0.074 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080251; EAN: 3245060802516; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080251-WEB-R.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6842043 | Installations électriques | Legrand_Batibox_support_1_poste_2_mod_080251 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676767 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_1_poste_2_mod_080251 | Legrand_Batibox_support_1_poste_2_mod_080251 | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000107341 m3; Surface: 0.00428326 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Fabricant: Legrand; Largeur: 0.074 m; Profondeur: 0.0072 m; Hauteur: 0.074 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080251; EAN: 3245060802516; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080251-WEB-R.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Family | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | N0_FINI
Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Type | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | N0_FINI
Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4816919 | Installations électriques | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 739385 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000380515 m3; Surface: 0.00659947 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.0085 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078722L; EAN: 3414971577541; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078722L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal; Couleur: Blanc antimicrobien; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
10 x Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Instance | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 739385 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Autre - Nom de la famille: Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L; Classe Etim: EC000007 Cadre de finition; Données d'identification - Nom du type: Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.082 m; Hauteur: 0.082 m; Profondeur: 0.0085 m; Electrique - Réf legrand: LG-078722L; EAN: 3414971577541; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078722L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Sens de montage: Horizontal; Couleur: Blanc antimicrobien; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4817320 | Installations électriques | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 739385 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000380515 m3; Surface: 0.00659947 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.0085 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078722L; EAN: 3414971577541; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078722L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal; Couleur: Blanc antimicrobien; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
