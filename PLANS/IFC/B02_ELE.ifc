Properties of the parts of a building model (IFC4), part 19 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4818075 | Installations électriques | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 739385 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000380515 m3; Surface: 0.00659947 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.0085 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078722L; EAN: 3414971577541; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078722L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal; Couleur: Blanc antimicrobien; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4818785 | Installations électriques | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 739385 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000380515 m3; Surface: 0.00659947 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.0085 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078722L; EAN: 3414971577541; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078722L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal; Couleur: Blanc antimicrobien; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821131 | Installations électriques | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 739385 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000380515 m3; Surface: 0.00659947 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.0085 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078722L; EAN: 3414971577541; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078722L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal; Couleur: Blanc antimicrobien; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821749 | Installations électriques | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 739385 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000380515 m3; Surface: 0.00659947 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.0085 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078722L; EAN: 3414971577541; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078722L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal; Couleur: Blanc antimicrobien; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821837 | Installations électriques | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 739385 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000380515 m3; Surface: 0.00659947 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.0085 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078722L; EAN: 3414971577541; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078722L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal; Couleur: Blanc antimicrobien; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822445 | Installations électriques | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 739385 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000380515 m3; Surface: 0.00659947 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.0085 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078722L; EAN: 3414971577541; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078722L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal; Couleur: Blanc antimicrobien; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822565 | Installations électriques | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 739385 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000380515 m3; Surface: 0.00659947 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.0085 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078722L; EAN: 3414971577541; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078722L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal; Couleur: Blanc antimicrobien; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822991 | Installations électriques | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 739385 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000380515 m3; Surface: 0.00659947 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.0085 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078722L; EAN: 3414971577541; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078722L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal; Couleur: Blanc antimicrobien; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Family | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Type | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4816921 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q1; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q1-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
41 x Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Instance | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 682338 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Autre - Nom de la famille: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Classe Etim: EC000125 Prise de courant; Données d'identification - Nom du type: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Note d'identification: 600_ELECTRICITE C.FORTS; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.045 m; Hauteur: 0.045 m; Profondeur: 0.039 m; Electrique - Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4817322 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q1; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q1-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4818077 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q1; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q1-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4818787 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q1; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q1-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821133 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q2; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q2-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821751 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q2; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q2-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821839 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q2; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q2-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822447 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q2; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q2-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822567 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q2; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q2-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822993 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q2; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q2-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840505 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q19; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q19-BD3; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840553 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q19; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q19-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840571 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q19; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q19-BD4; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840599 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q19; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q19-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Instance | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5787769 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Autre - Nom de la famille: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Classe Etim: EC000125 Prise de courant; Données d'identification - Nom du type: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.045 m; Hauteur: 0.045 m; Profondeur: 0.039 m; Electrique - Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840617 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q19; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q19-BD4; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840635 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q19; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q19-BD3; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755786 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q30; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q30-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755796 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q30; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q30-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755802 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q30; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q30-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755812 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q30; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q30-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755818 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q29; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q29-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755828 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q29; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q29-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755834 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q29; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q29-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755844 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q29; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q29-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
