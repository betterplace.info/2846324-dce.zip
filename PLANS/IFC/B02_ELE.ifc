Properties of the parts of a building model (IFC4), part 25 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798398 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q18; GEM_ELE_NOM TABLEAU: TD1; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q18-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798406 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q17; GEM_ELE_NOM TABLEAU: TD1; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q17-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798410 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q17; GEM_ELE_NOM TABLEAU: TD1; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q17-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798429 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q16; GEM_ELE_NOM TABLEAU: TD1; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q16-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798433 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q16; GEM_ELE_NOM TABLEAU: TD1; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q16-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043 | Family | Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043 | <NoLevel>
Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043 | Type | Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043 | <NoLevel>
Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043 | Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043 | Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043 | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 4824060 | Installations électriques | Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043 | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1607218 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043 | Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Cotes - Volume: 0.0000343553 m3; Surface: 0.0351146 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.213 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080043; EAN: 3245060800437; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080043-LEGRAND-1000.jpg; Contraintes - Se déplace avec les éléments voisins: no
Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043 | Instance | Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043 | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 1607218 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043 | Autre - Nom de la famille: Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043; Classe Etim: EC002601 Boîte d'appareillage encastré; Données d'identification - Nom du type: Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.213 m; Diamètre: 0.067 m; Hauteur: 0.0728 m; Profondeur: 0.04 m; Electrique - Réf legrand: LG-080043; EAN: 3245060800437; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080043-LEGRAND-1000.jpg; Fabricant: Legrand
Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253 | Family | Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253 | <NoLevel>
Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253 | Type | Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253 | <NoLevel>
Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253 | Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253 | Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253 | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 4824061 | Installations électriques | Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253 | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1607217 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253 | Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Cotes - Volume: 0.0000229658 m3; Surface: 0.0092029 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.216 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080253; EAN: 3245060802530; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080253-WEB-R.jpg; Nombre de modules horizontaux: 8; Sens de montage: Horizontal et vertical; Fixation: A vis; Contraintes - Se déplace avec les éléments voisins: no
Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253 | Instance | Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253 | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 1607217 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253 | Autre - Nom de la famille: Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253; Classe Etim: EC002948 support pour installation domotique modulaire; Données d'identification - Nom du type: Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.216 m; Hauteur: 0.077 m; Profondeur: 0.0157 m; Electrique - Réf legrand: LG-080253; EAN: 3245060802530; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080253-WEB-R.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 8; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Mosaic_vide | Family | Legrand_Mosaic_vide | <NoLevel>
Legrand_Mosaic_vide | Type | Legrand_Mosaic_vide | <NoLevel>
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 4824062 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 4824064 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 4824066 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 4824068 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798397 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798399 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798409 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798411 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798432 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798434 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Se déplace avec les éléments voisins: no
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Family | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | <NoLevel>
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Type | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | <NoLevel>
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 4824065 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; GEM_ELE_CFA_SS REP: PB1; CLE ID APPAREILS CFA: ECRAN CONNECTE/TELEVISEUR; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A1; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: ECRAN CONNECTE/TELEVISEUR
2 x Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Instance | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 1147599 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Autre - Nom de la famille: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Données d'identification - Nom du type: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Note d'identification: 610_ELECTRICITE C.FAIBLES; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.045 m; Hauteur: 0.045 m; Profondeur: 0.0337 m; Electrique - Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Catégorie: 6
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 4824067 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; GEM_ELE_CFA_SS REP: PB1; CLE ID APPAREILS CFA: ECRAN CONNECTE/TELEVISEUR; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A2; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: ECRAN CONNECTE/TELEVISEUR
Legrand_Mosaic_plaque_4_mod_blanc_078814L | Family | Legrand_Mosaic_plaque_4_mod_blanc_078814L | <NoLevel>
Legrand_Mosaic_plaque_4_mod_blanc_078814L | Type | Legrand_Mosaic_plaque_4_mod_blanc_078814L | <NoLevel>
Legrand_Mosaic_plaque_4_mod_blanc_078814L | Legrand_Mosaic_plaque_4_mod_blanc_078814L | Legrand_Mosaic_plaque_4_mod_blanc_078814L | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798393 | Installations électriques | Legrand_Mosaic_plaque_4_mod_blanc_078814L | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1602420 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_4_mod_blanc_078814L | Legrand_Mosaic_plaque_4_mod_blanc_078814L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Cotes - Volume: 0.0000688402 m3; Surface: 0.011212 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078814L; EAN: 3414971577947; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078814L-WEB-F.jpg; Nombre de modules horizontaux: 4; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04; Contraintes - Se déplace avec les éléments voisins: no
3 x Legrand_Mosaic_plaque_4_mod_blanc_078814L | Instance | Legrand_Mosaic_plaque_4_mod_blanc_078814L | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 1602420 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_plaque_4_mod_blanc_078814L | Autre - Nom de la famille: Legrand_Mosaic_plaque_4_mod_blanc_078814L; Classe Etim: EC000007 Cadre de finition; Données d'identification - Nom du type: Legrand_Mosaic_plaque_4_mod_blanc_078814L; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.153 m; Hauteur: 0.082 m; Profondeur: 0.009 m; Electrique - Réf legrand: LG-078814L; EAN: 3414971577947; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078814L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 4; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_4_mod_blanc_078814L | Legrand_Mosaic_plaque_4_mod_blanc_078814L | Legrand_Mosaic_plaque_4_mod_blanc_078814L | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798405 | Installations électriques | Legrand_Mosaic_plaque_4_mod_blanc_078814L | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1602420 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_4_mod_blanc_078814L | Legrand_Mosaic_plaque_4_mod_blanc_078814L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Cotes - Volume: 0.0000688402 m3; Surface: 0.011212 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078814L; EAN: 3414971577947; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078814L-WEB-F.jpg; Nombre de modules horizontaux: 4; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04; Contraintes - Se déplace avec les éléments voisins: no
Legrand_Mosaic_plaque_4_mod_blanc_078814L | Legrand_Mosaic_plaque_4_mod_blanc_078814L | Legrand_Mosaic_plaque_4_mod_blanc_078814L | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798428 | Installations électriques | Legrand_Mosaic_plaque_4_mod_blanc_078814L | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1602420 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_4_mod_blanc_078814L | Legrand_Mosaic_plaque_4_mod_blanc_078814L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Cotes - Volume: 0.0000688402 m3; Surface: 0.011212 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078814L; EAN: 3414971577947; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078814L-WEB-F.jpg; Nombre de modules horizontaux: 4; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04; Contraintes - Se déplace avec les éléments voisins: no
Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | Family | Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | <NoLevel>
Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | Type | Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | <NoLevel>
Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798395 | Installations électriques | Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1632074 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg; Contraintes - Se déplace avec les éléments voisins: no
3 x Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | Instance | Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 1632074 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | Autre - Nom de la famille: Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042; Classe Etim: EC002601 Boîte d'appareillage encastré; Données d'identification - Nom du type: Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.142 m; Diamètre: 0.067 m; Hauteur: 0.0728 m; Profondeur: 0.04 m; Electrique - Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg; Fabricant: Legrand
Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798407 | Installations électriques | Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1632074 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg; Contraintes - Se déplace avec les éléments voisins: no
Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798430 | Installations électriques | Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1632074 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | Legrand_Batibox_boîte_cloison_sèche_prof_40_2_postes_4_5_mod_horizontal_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg; Contraintes - Se déplace avec les éléments voisins: no
Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | Family | Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | <NoLevel>
Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | Type | Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | <NoLevel>
Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798396 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1632073 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis; Contraintes - Se déplace avec les éléments voisins: no
3 x Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | Instance | Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 1632073 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | Autre - Nom de la famille: Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252; Classe Etim: EC002948 support pour installation domotique modulaire; Données d'identification - Nom du type: Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.145 m; Hauteur: 0.077 m; Profondeur: 0.0157 m; Electrique - Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798408 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1632073 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis; Contraintes - Se déplace avec les éléments voisins: no
Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798431 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1632073 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | Legrand_Batibox_support_2_postes_4_5_mod_horizontal_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis; Contraintes - Se déplace avec les éléments voisins: no
Tableaux/Baies | Category | Tableaux/Baies | <NoLevel>
602_BOITE DE DERIVATION | Family | 602_BOITE DE DERIVATION | <NoLevel>
105X105X50 GENERIQUE | Type | 105X105X50 GENERIQUE | <NoLevel>
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 6793288 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q32; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Élévation par rapport au niveau: 0 m; Cotes - Volume: 0.0000819755 m3; Surface: 0.041129 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 32; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 7 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 1520 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 0 A; Courant de Phase B: 7 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 7 A; Intensité installée totale: 7 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 1520 VA; Puissance apparente installée totale: 1520 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 1520 VA; Puissance apparente - Phase A: 0 VA; PC 2P+T 230V - Puissance apparente installée: 1520 VA; PC 2P+T 230V - Puissance apparente requise: 1520 VA; PC 2P+T 230V - Intensité installée: 7 A; PC 2P+T 230V - Intensité requise estimée: 7 A; PC 2P+T 230V - Coefficient d'utilisation: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.24; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Emplacement: Pièce DC-N0-016; Nom du panneau: TD1-Q32-BD1; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: PC 230N; Texte - TEXTE 3D: TD1-Q32-BD1
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 7158457 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 6793397 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q31; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Élévation par rapport au niveau: 0 m; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411013 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 31; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 7 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 1520 VA; Courant de Phase C: 0 A; Courant de Phase B: 0 A; Courant de Phase A: 7 A; Intensité requise estimée totale: 7 A; Intensité installée totale: 7 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 1520 VA; Puissance apparente installée totale: 1520 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 1520 VA; PC 2P+T 230V - Puissance apparente installée: 1520 VA; PC 2P+T 230V - Puissance apparente requise: 1520 VA; PC 2P+T 230V - Intensité installée: 7 A; PC 2P+T 230V - Intensité requise estimée: 7 A; PC 2P+T 230V - Coefficient d'utilisation: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.24; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Emplacement: Pièce DC-N0-016; Nom du panneau: TD1-Q31-BD1; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: PC 230N; Texte - TEXTE 3D: TD1-Q31-BD1
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 7158454 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 6793841 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q28; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Élévation par rapport au niveau: 0 m; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411446 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 28; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 10 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 2280 VA; Courant de Phase C: 0 A; Courant de Phase B: 0 A; Courant de Phase A: 10 A; Intensité requise estimée totale: 10 A; Intensité installée totale: 10 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 2280 VA; Puissance apparente installée totale: 2280 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 2280 VA; PC 2P+T 230V - Puissance apparente installée: 2280 VA; PC 2P+T 230V - Puissance apparente requise: 2280 VA; PC 2P+T 230V - Intensité installée: 10 A; PC 2P+T 230V - Intensité requise estimée: 10 A; PC 2P+T 230V - Coefficient d'utilisation: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Nom du panneau: TD1-Q28-BD1; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: PC 230N; Texte - TEXTE 3D: TD1-Q28-BD1
