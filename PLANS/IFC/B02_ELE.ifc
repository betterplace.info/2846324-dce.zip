Properties of the parts of a building model (IFC4), part 16 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4804977 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q3; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q3-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805050 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q4; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q4-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805052 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q4; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q4-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805551 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q7; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q7-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805553 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q7; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q7-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805884 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q8; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q8-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805886 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q8; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q8-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755784 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q7; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q7-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755790 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q8; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q8-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755792 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q8; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q8-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755794 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q8; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q8-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755800 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q5; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q5-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755806 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q6; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q6-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755808 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q6; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q6-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755810 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q6; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q6-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755816 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q10; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q10-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755822 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q12; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q12-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755824 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q12; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q12-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755826 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q12; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q12-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755832 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q11; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q11-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755838 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q13; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q13-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755840 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q13; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q13-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755842 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q13; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q13-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755848 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q10; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q10-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755854 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q14; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q14-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755856 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q14; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q14-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755858 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q14; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q14-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755864 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q11; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q11-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755870 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q15; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q15-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755872 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q15; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q15-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755874 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q15; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q15-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
