Properties of the parts of a building model (IFC4), part 24 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
603_DETECTEUR PD4-M-1C-C-PS | Instance | 603_DETECTEUR PD4-M-1C-C-PS | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 5044805 | Installations électriques |  |  | Famille : Installations électriques : 603_DETECTEUR PD4-M-1C-C-PS | Autre - Nom de la famille: 603_DETECTEUR PD4-M-1C-C-PS; ZZZ_V E_c01_Z_Length: 0 m; ZZZ_V E_c01_Y_Length: 0 m; ZZZ_V E_c01_plane_Integer: 1; ZZZ_V E_c01_X_Length: 0 m; TBQfr_E_c01_oui_non: yes; RSfr_E_c01_description: -; TBQfr_E_c01_type_de_système: -; Données d'identification - Nom du type: CATALOGUE DE TYPE; Note d'identification: 600_ELECTRICITE C.FORTS; Modèle: capteur de mouvement; Fabricant: B.E.G.; URL: -; Description: capteur de mouvement; Code d'assemblage: 62.60.10; RSen_C_content_date_issue: 29/09/2023; RSfr_C_type: capteur de mouvement; RSfr_C_content_version: 1.0.0; RSfr_C_revit_version: 2020; TBQfr_C_licence_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; RSfr_C_code_gtin: -; RSfr_C_type_commentaires: capteur de mouvement; RSfr_C_code_ETIM_url: http://prod.etim-international.com/; RSfr_C_content_date_modifié: 29/09/2023; TBQfr_C_code_produit: -; RSfr_C_content_fournisseur: B.E.G.; RSfr_C_content_créateur: © ThorbiQ; RSfr_C_description: capteur de mouvement; RSfr_C_code_article: -; TBQfr_C_IFC_version: 2x3; RSfr_C_code_classe_de_produit: -; RSfr_C_modèle: capteur de mouvement; TBQfr_C_licence: Creative Commons Attribution NoDerivs (CC-ND); TBQfr_C_accessoire_01_description: -; TBQ_I BaseKeynote: 62.60.10; Contraintes - Elévation par défaut: 0 m; ZZZ_Cut out_X_Length: 0 m; ZZZ_Logo_Z_Length: 0 m; ZZZ_Height_Width_Length: 0.076 m; ZZZ_Width_Length: 0.101 m; ZZZ_Suspension_YesNo: no; ZZZ_Cut out_Y_Length: 0 m; ZZZ_Const_06_Length: 0 m; ZZZ_Width_Height_Length: 0.101 m; ZZZ_Recessed_YesNo: no; ZZZ_Cut out_length_Length: 0 m; ZZZ_Const_05_Length: 0 m; ZZZ_Parallel wall mounted_YesNo: no; ZZZ_Const_04_Length: 0 m; ZZZ_Logo_plane_Integer: 2; ZZZ_Detection zone_rotation_Angle: 0 deg; ZZZ_Mounted_ceiling_YesNo: no; ZZZ_Logo_Y_Length: 0 m; ZZZ_Cut out_length__Length: 0.001 m; ZZZ_Detection zone_X_Length: 0 m; ZZZ_Cut out_height_Length: 0 m; ZZZ_Cut out_width__Length: 0.001 m; ZZZ_Pendant - vertical mounted_YesNo: no; ZZZ_Logo_X_Length: 0 m; ZZZ_Zones_plane_Integer: 2; ZZZ_Cut out_width_Length: 0 m; ZZZ_Const_03_Length: 0 m; ZZZ_Displacement_Y_Length: 0 m; ZZZ_Height negative_Length: -0.076 m; ZZZ_Height_Length: 0.076 m; ZZZ_Detection zone_plane_Integer: 1; ZZZ_Detection zone_Z_Length: 0 m; ZZZ_Pendant - horizontal mounted_YesNo: no; ZZZ_Logo_Rotation about axis_Angle: 180 deg; ZZZ_Cut out_diameter_Length: 0 m; ZZZ_Surface mounted_YesNo: yes; ZZZ_IP_YesNo: no; ZZZ_Recess depth_Length: 0 m; ZZZ_Mounted_wall_YesNo: yes; ZZZ_Angled wall mounted_YesNo: no; ZZZ_Cut out_radius_Length: 0.001 m; ZZZ_Detection zone_Y_Length: 0 m; ZZZ_Cut out_height negative_Length: -0.002 m; ZZZ_Const_01_Length: 0 m; ZZZ_Length_Length: 0.101 m; ZZZ_Const_02_Length: 0 m; ZZZ_Placeholder for SOg_FamilyType_Lighting Devices: aucun; ZZZ_Detection zone_3D_standard_FamilyType_Lighting Devices: standard; ZZZ_Visualized connectors_FamilyType_Generic Models: standard; ZZZ_Detection zone_3D_none_FamilyType_Lighting Devices: standard; ZZZ_Bounding Box_FamilyType_Lighting Devices: standard; ZZZ_Annotation_FamilyType_Generic Annotations: standard; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: MOVEMENTSENSOR; Exporter le type au format IFC sous: IfcAirTerminalType; IfcExportAs: IfcAirTerminalType; IfcExportType: MOVEMENTSENSOR; Construction - ZZZ_V Component_02_X_Length: 0 m; ZZZ_V Component_01_width_Length: 0 m; ZZZ_V Component_03_width_Length: 0 m; ZZZ_V Component_03_Y_Length: 0 m; ZZZ_V Component_01_Z_Length: 0 m; ZZZ_V Component_03_length_Length: 0 m; ZZZ_V Component_03_height_Length: 0 m; ZZZ_V Suspension_plane_Integer: 2; ZZZ_V Component_01_plane_Integer: 1; ZZZ_V Component_03_diameter_Length: 0 m; ZZZ_V SOg_plane_Integer: 2; ZZZ_V Component_02_width_Length: 0 m; ZZZ_V Component_02_Z_Length: 0 m; ZZZ_V SOg_X_Length: 0 m; ZZZ_V Component_03_Z_Length: 0 m; ZZZ_V SOg_Y_Length: 0 m; ZZZ_V Component_01_length_Length: 0 m; ZZZ_V Component_03_plane_Integer: 1; ZZZ_V Component_01_height_Length: 0.076 m; ZZZ_V Suspension_Y_Length: 0 m; ZZZ_V Component_02_Y_Length: 0 m; ZZZ_V Component_01_X_Length: 0 m; ZZZ_V Component_02_length_Length: 0 m; ZZZ_V Component_02_height_Length: 0 m; ZZZ_V Component_03_X_Length: 0 m; ZZZ_V Component_02_description_Text: -; ZZZ_V Component_02_diameter_Length: 0 m; ZZZ_V SOg_rotation_Angle: 0 deg; ZZZ_V Suspension_offset_Length: 0 m; ZZZ_V Suspension_width_Length: 0 m; ZZZ_V Component_01_diameter_Length: 0.101 m; ZZZ_V Component_03_description_Text: -; ZZZ_V SOg_Z_Length: 0 m; ZZZ_V Suspension_X_Length: 0 m; ZZZ_V Component_02_plane_Integer: 2; ZZZ_V Component_01_description_Text: détecteur; ZZZ_V Component_01_Y_Length: 0 m; ZZZ_V Suspension_length_Length: 0 m; ZZZ_V Suspension_type_FamilyType_Lighting Devices: aucun_gen; TBQfr_C_SOg_LD_2D: aucun; TBQfr_C_accessoires_EE_02: aucun_gen; TBQfr_C_accessoires_EE_05: aucun_gen; TBQfr_C_accessoires_EE_03: aucun_gen; TBQfr_C_SOg_LD_3D: aucun; TBQfr_C_accessoires_EE_04: aucun_gen; Graphismes - ZZZ_V Clearance zone_bottom_Length: 0 m; ZZZ_V Clearance zone_top_Length: 0 m; ZZZ_V Clearance zone_right_Length: 0 m; ZZZ_V Clearance zone_back_Length: 0 m; ZZZ_V Clearance zone_front_Length: 0 m; ZZZ_V Clearance zone_left_Length: 0 m; Propriétés du modèle - ZZZ_V Light sensor_YesNo: no; ZZZ_V Detection range at height_Length: 2.5 m; ZZZ_V Detection range_02_max height_Length: 5 m; ZZZ_V Detection angle_Angle: 360 deg; ZZZ_V Detection range_01_Length: 40 m; ZZZ_V Ventilation control_YesNo: no; ZZZ_V IP_Integer: 0; ZZZ_V Detection range_01_max height_Length: 5 m; ZZZ_V Detection range_03_max height_Length: 3.5 m; ZZZ_V Detection range_03_Length: 5 m; ZZZ_V Detection range_02_Length: 7 m; ZZZ_V Dimmer_YesNo: no; ZZZ_V Suspension_min_Length: 0 m; ZZZ_V Suspension_max_Length: 0 m; TBQ_I Domaine de saisie des données: -; TBQ_I Maître: yes; TBQ_I Esclave: no; TBQ_I Type de sortie: -; Scénario: -; Couleur: -; Dimensions du bloc d'alimentation externe: -; Puissance interne W: -; Absorption de courant mA: -; Réglages: -; Surface contrôlée approche tangentielle m² à une hauteur de montage de 2,5 m: -; Hauteur de montage Min. m: -; Hauteur de montage Max. m: -; Hauteur de montage Recommandé m: -; Mesurage du lumière: -; Évaluation de la température: -; Boîtier: -; Longeur de cable cm: -; KNX Nombre de capteurs de luminosité: -; KNX Nombre de capteurs PIR: -; KNX TP 256: -; Canal 01: -; Canal 01 Puissance: -; Canal 01 Lumière d’orientation: -; Canal 01 Nachtlicht: -; Canal 02: -; Canal 02 Puissance: -; Canal 02 Durée de temporisation: -; Canal 02 Lumière d’orientation: -; Canal 02 Seuil d´enchlenchement Lux: -; Détecteur Largeur en mm: -; Détecteur Hauteur en mm: -; Détecteur Profondeur en mm: -; Matériaux et finitions - ZZZ_V Detection zone_03_material_Material: RSfr_x_rgb 000 128 000 T80 vert_gen; ZZZ_V Clearance zone_material_Material: RSfr_x_rgb 255 128 128 T80 rouge_gen; ZZZ_V Detection zone_02_material_Material: RSfr_x_rgb 000 128 255 T80 bleu_gen; ZZZ_V Detection zone_01_material_Material: RSfr_x_rgb 255 128 128 T80 rouge_gen; Cotes - RSfr_C_largeur: 0 m; RSfr_C_hauteur: 0.076 m; RSfr_C_longueur: 0 m; RSfr_C_diamètre: 0.101 m; Electrique - RSfr_E_c01_puissance_apparente: 0 VA; RSfr_E_c01_nombre_de_pôles: 1; RSfr_E_c01_tension: 230 V; RSfr_E_c01_sous_indice_de_charge_moteur: no
606_ALIMENTATION SPECIFIQUE | Family | 606_ALIMENTATION SPECIFIQUE | S1
400V 3P+N | Type | 400V 3P+N | S1
606_ALIMENTATION SPECIFIQUE | 400V 3P+N | 606_ALIMENTATION SPECIFIQUE | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 6934163 | Installations électriques | 400V 3P+N | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 |  |  |  |  | 5995997 | 0 | Installations électriques | 0 | Famille : Installations électriques : 606_ALIMENTATION SPECIFIQUE | 606_ALIMENTATION SPECIFIQUE | Contraintes - Niveau: S1; Décalage par rapport à l'hôte: 1 m; Élévation par rapport au niveau: 1 m; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.00128 m3; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.5; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Electric Power and Lighting; Numéro OmniClass: 23.80.00.00; TENSION: 400 V; NOMBRE POLES: 3
606_ALIMENTATION SPECIFIQUE | Instance | 606_ALIMENTATION SPECIFIQUE | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 5995997 | Installations électriques |  |  | Famille : Installations électriques : 606_ALIMENTATION SPECIFIQUE | Autre - Nom de la famille: 606_ALIMENTATION SPECIFIQUE; Données d'identification - Nom du type: 400V 3P+N; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Electric Power and Lighting; Numéro OmniClass: 23.80.00.00; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Electrotechnique - TENSION: 400 V; NOMBRE POLES: 3
603_3POSTES_VERTICAUX_PLEXO | Family | 603_3POSTES_VERTICAUX_PLEXO | S1
603_3POSTES_VERTICAUX_PLEXO | Type | 603_3POSTES_VERTICAUX_PLEXO | S1
603_3POSTES_VERTICAUX_PLEXO | 603_3POSTES_VERTICAUX_PLEXO | 603_3POSTES_VERTICAUX_PLEXO | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091324 | Installations électriques | 603_3POSTES_VERTICAUX_PLEXO | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 |  |  |  |  | 7091303 | 0.0011 | Installations électriques | 0 | Famille : Installations électriques : 603_3POSTES_VERTICAUX_PLEXO | 603_3POSTES_VERTICAUX_PLEXO | Contraintes - Niveau: S1; Décalage par rapport à l'hôte: 1 m; Élévation par rapport au niveau: 1 m; Se déplace avec les éléments voisins: no; Type de Revit - Titre OmniClass: Electric Power and Lighting; Numéro OmniClass: 23.80.00.00; Module 1: Legrand_Plexo_composable_poussoir_NO_gris_069540L; Module 2: Legrand_Plexo_composable_prise_FB_gris_069551L; Module 3: Legrand_Plexo_composable_prise_FB_gris_069551L; Type de boite d'encastrement: Legrand_Plexo_vide; Boite d'encastrement: no; Type de boitier ou de support: Legrand_Plexo_boitier_vertical_3_postes_gris_069680L; CALC_DS: 0.0512 m
603_3POSTES_VERTICAUX_PLEXO | 603_3POSTES_VERTICAUX_PLEXO | 603_3POSTES_VERTICAUX_PLEXO | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091524 | Installations électriques | 603_3POSTES_VERTICAUX_PLEXO | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 |  |  |  |  | 7091303 | 0.0011 | Installations électriques | 0 | Famille : Installations électriques : 603_3POSTES_VERTICAUX_PLEXO | 603_3POSTES_VERTICAUX_PLEXO | Contraintes - Niveau: S1; Décalage par rapport à l'hôte: 1 m; Élévation par rapport au niveau: 1 m; Se déplace avec les éléments voisins: no; Type de Revit - Titre OmniClass: Electric Power and Lighting; Numéro OmniClass: 23.80.00.00; Module 1: Legrand_Plexo_composable_poussoir_NO_gris_069540L; Module 2: Legrand_Plexo_composable_prise_FB_gris_069551L; Module 3: Legrand_Plexo_composable_prise_FB_gris_069551L; Type de boite d'encastrement: Legrand_Plexo_vide; Boite d'encastrement: no; Type de boitier ou de support: Legrand_Plexo_boitier_vertical_3_postes_gris_069680L; CALC_DS: 0.0512 m
603_3POSTES_VERTICAUX_PLEXO | 603_3POSTES_VERTICAUX_PLEXO | 603_3POSTES_VERTICAUX_PLEXO | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091544 | Installations électriques | 603_3POSTES_VERTICAUX_PLEXO | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 |  |  |  |  | 7091303 | 0.0011 | Installations électriques | 0 | Famille : Installations électriques : 603_3POSTES_VERTICAUX_PLEXO | 603_3POSTES_VERTICAUX_PLEXO | Contraintes - Niveau: S1; Décalage par rapport à l'hôte: 1 m; Élévation par rapport au niveau: 1 m; Se déplace avec les éléments voisins: no; Type de Revit - Titre OmniClass: Electric Power and Lighting; Numéro OmniClass: 23.80.00.00; Module 1: Legrand_Plexo_composable_poussoir_NO_gris_069540L; Module 2: Legrand_Plexo_composable_prise_FB_gris_069551L; Module 3: Legrand_Plexo_composable_prise_FB_gris_069551L; Type de boite d'encastrement: Legrand_Plexo_vide; Boite d'encastrement: no; Type de boitier ou de support: Legrand_Plexo_boitier_vertical_3_postes_gris_069680L; CALC_DS: 0.0512 m
603_3POSTES_VERTICAUX_PLEXO | 603_3POSTES_VERTICAUX_PLEXO | 603_3POSTES_VERTICAUX_PLEXO | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091552 | Installations électriques | 603_3POSTES_VERTICAUX_PLEXO | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 |  |  |  |  | 7091303 | 0.0011 | Installations électriques | 0 | Famille : Installations électriques : 603_3POSTES_VERTICAUX_PLEXO | 603_3POSTES_VERTICAUX_PLEXO | Contraintes - Niveau: S1; Décalage par rapport à l'hôte: 1 m; Élévation par rapport au niveau: 1 m; Se déplace avec les éléments voisins: no; Type de Revit - Titre OmniClass: Electric Power and Lighting; Numéro OmniClass: 23.80.00.00; Module 1: Legrand_Plexo_composable_poussoir_NO_gris_069540L; Module 2: Legrand_Plexo_composable_prise_FB_gris_069551L; Module 3: Legrand_Plexo_composable_prise_FB_gris_069551L; Type de boite d'encastrement: Legrand_Plexo_vide; Boite d'encastrement: no; Type de boitier ou de support: Legrand_Plexo_boitier_vertical_3_postes_gris_069680L; CALC_DS: 0.0512 m
Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Family | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | S1
Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Type | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | S1
Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091325 | Installations électriques | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081495 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Contraintes - Niveau: S1; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000197806 m3; Surface: 0.056248 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.8; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.057 m; Hauteur: 0.226 m; Classe Etim: LC000080 Boîtier en saillie; Réf legrand: LG-069680L; EAN: 3414971881280; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069680L-WEB-R2.jpg; Sens de montage: Horizontal et vertical; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 57; IK: 08; Nombre de poste: 3
4 x Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Instance | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7081495 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Autre - Nom de la famille: Legrand_Plexo_boitier_vertical_3_postes_gris_069680L; Classe Etim: LC000080 Boîtier en saillie; Données d'identification - Nom du type: Legrand_Plexo_boitier_vertical_3_postes_gris_069680L; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.082 m; Hauteur: 0.226 m; Profondeur: 0.057 m; Electrique - Réf legrand: LG-069680L; EAN: 3414971881280; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069680L-WEB-R2.jpg; Fabricant: Legrand; Sens de montage: Horizontal et vertical; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 57; IK: 08; Nombre de poste: 3
Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091525 | Installations électriques | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081495 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Contraintes - Niveau: S1; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000197806 m3; Surface: 0.056248 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.7; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.057 m; Hauteur: 0.226 m; Classe Etim: LC000080 Boîtier en saillie; Réf legrand: LG-069680L; EAN: 3414971881280; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069680L-WEB-R2.jpg; Sens de montage: Horizontal et vertical; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 57; IK: 08; Nombre de poste: 3
Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091545 | Installations électriques | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081495 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Contraintes - Niveau: S1; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000197806 m3; Surface: 0.056248 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.6; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.057 m; Hauteur: 0.226 m; Classe Etim: LC000080 Boîtier en saillie; Réf legrand: LG-069680L; EAN: 3414971881280; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069680L-WEB-R2.jpg; Sens de montage: Horizontal et vertical; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 57; IK: 08; Nombre de poste: 3
Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091553 | Installations électriques | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081495 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Legrand_Plexo_boitier_vertical_3_postes_gris_069680L | Contraintes - Niveau: S1; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000197806 m3; Surface: 0.056248 m2; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.057 m; Hauteur: 0.226 m; Classe Etim: LC000080 Boîtier en saillie; Réf legrand: LG-069680L; EAN: 3414971881280; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069680L-WEB-R2.jpg; Sens de montage: Horizontal et vertical; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 57; IK: 08; Nombre de poste: 3
Legrand_Plexo_composable_poussoir_NO_gris_069540L | Family | Legrand_Plexo_composable_poussoir_NO_gris_069540L | S1
Legrand_Plexo_composable_poussoir_NO_gris_069540L | Type | Legrand_Plexo_composable_poussoir_NO_gris_069540L | S1
Legrand_Plexo_composable_poussoir_NO_gris_069540L | Legrand_Plexo_composable_poussoir_NO_gris_069540L | Legrand_Plexo_composable_poussoir_NO_gris_069540L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091326 | Installations électriques | Legrand_Plexo_composable_poussoir_NO_gris_069540L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081480 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_composable_poussoir_NO_gris_069540L | Legrand_Plexo_composable_poussoir_NO_gris_069540L | Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Cotes - Volume: 0.0000421601 m3; Surface: 0.00827534 m2; Electricité - Charges - Panneau: TD1-Q36-BD4; Numero de circuit: 1; Charge: 100 VA; Electricité - Circuit - Données électriques: 250 V/1-100 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.8; Type de Revit - Fabricant: Legrand; Largeur: 0.07 m; Profondeur: 0.046 m; Hauteur: 0.07 m; Classe Etim: LC000029 Bouton poussoir; Réf legrand: LG-069540L; EAN: 3414971878587; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069540L-WEB-R.jpg; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 55; IK: 08; Courant nominal: 10 A; Tension nominale: 250 V; Type de contacts: 1 contact à fermeture; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m
4 x Legrand_Plexo_composable_poussoir_NO_gris_069540L | Instance | Legrand_Plexo_composable_poussoir_NO_gris_069540L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7081480 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Plexo_composable_poussoir_NO_gris_069540L | Autre - Nom de la famille: Legrand_Plexo_composable_poussoir_NO_gris_069540L; Classe Etim: LC000029 Bouton poussoir; Données d'identification - Nom du type: Legrand_Plexo_composable_poussoir_NO_gris_069540L; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.07 m; Hauteur: 0.07 m; Profondeur: 0.046 m; Electrique - Réf legrand: LG-069540L; EAN: 3414971878587; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069540L-WEB-R.jpg; Fabricant: Legrand; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 55; IK: 08; Courant nominal: 10 A; Tension nominale: 250 V; Type de contacts: 1 contact à fermeture
Legrand_Plexo_composable_poussoir_NO_gris_069540L | Legrand_Plexo_composable_poussoir_NO_gris_069540L | Legrand_Plexo_composable_poussoir_NO_gris_069540L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091526 | Installations électriques | Legrand_Plexo_composable_poussoir_NO_gris_069540L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081480 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_composable_poussoir_NO_gris_069540L | Legrand_Plexo_composable_poussoir_NO_gris_069540L | Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Cotes - Volume: 0.0000421601 m3; Surface: 0.00827534 m2; Electricité - Charges - Panneau: TD1-Q36-BD5; Numero de circuit: 1; Charge: 100 VA; Electricité - Circuit - Données électriques: 250 V/1-100 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.7; Type de Revit - Fabricant: Legrand; Largeur: 0.07 m; Profondeur: 0.046 m; Hauteur: 0.07 m; Classe Etim: LC000029 Bouton poussoir; Réf legrand: LG-069540L; EAN: 3414971878587; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069540L-WEB-R.jpg; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 55; IK: 08; Courant nominal: 10 A; Tension nominale: 250 V; Type de contacts: 1 contact à fermeture; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m
Legrand_Plexo_composable_poussoir_NO_gris_069540L | Legrand_Plexo_composable_poussoir_NO_gris_069540L | Legrand_Plexo_composable_poussoir_NO_gris_069540L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091546 | Installations électriques | Legrand_Plexo_composable_poussoir_NO_gris_069540L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081480 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_composable_poussoir_NO_gris_069540L | Legrand_Plexo_composable_poussoir_NO_gris_069540L | Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Cotes - Volume: 0.0000421601 m3; Surface: 0.00827534 m2; Electricité - Charges - Panneau: TD1-Q36-BD3; Numero de circuit: 1; Charge: 100 VA; Electricité - Circuit - Données électriques: 250 V/1-100 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.6; Type de Revit - Fabricant: Legrand; Largeur: 0.07 m; Profondeur: 0.046 m; Hauteur: 0.07 m; Classe Etim: LC000029 Bouton poussoir; Réf legrand: LG-069540L; EAN: 3414971878587; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069540L-WEB-R.jpg; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 55; IK: 08; Courant nominal: 10 A; Tension nominale: 250 V; Type de contacts: 1 contact à fermeture; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m
Legrand_Plexo_composable_poussoir_NO_gris_069540L | Legrand_Plexo_composable_poussoir_NO_gris_069540L | Legrand_Plexo_composable_poussoir_NO_gris_069540L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091554 | Installations électriques | Legrand_Plexo_composable_poussoir_NO_gris_069540L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081480 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_composable_poussoir_NO_gris_069540L | Legrand_Plexo_composable_poussoir_NO_gris_069540L | Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Cotes - Volume: 0.0000421601 m3; Surface: 0.00827534 m2; Electricité - Charges - Panneau: TD1-Q36-BD2; Numero de circuit: 1; Charge: 100 VA; Electricité - Circuit - Données électriques: 250 V/1-100 VA; Type de Revit - Fabricant: Legrand; Largeur: 0.07 m; Profondeur: 0.046 m; Hauteur: 0.07 m; Classe Etim: LC000029 Bouton poussoir; Réf legrand: LG-069540L; EAN: 3414971878587; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069540L-WEB-R.jpg; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 55; IK: 08; Courant nominal: 10 A; Tension nominale: 250 V; Type de contacts: 1 contact à fermeture; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m
Legrand_Plexo_vide | Family | Legrand_Plexo_vide | S1
Legrand_Plexo_vide | Type | Legrand_Plexo_vide | S1
Legrand_Plexo_vide | Legrand_Plexo_vide | Legrand_Plexo_vide | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091327 | Installations électriques | Legrand_Plexo_vide | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081427 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_vide | Legrand_Plexo_vide | Contraintes - Niveau: S1; Se déplace avec les éléments voisins: no
Legrand_Plexo_vide | Legrand_Plexo_vide | Legrand_Plexo_vide | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091527 | Installations électriques | Legrand_Plexo_vide | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081427 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_vide | Legrand_Plexo_vide | Contraintes - Niveau: S1; Se déplace avec les éléments voisins: no
Legrand_Plexo_vide | Legrand_Plexo_vide | Legrand_Plexo_vide | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091547 | Installations électriques | Legrand_Plexo_vide | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081427 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_vide | Legrand_Plexo_vide | Contraintes - Niveau: S1; Se déplace avec les éléments voisins: no
Legrand_Plexo_vide | Legrand_Plexo_vide | Legrand_Plexo_vide | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091555 | Installations électriques | Legrand_Plexo_vide | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081427 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_vide | Legrand_Plexo_vide | Contraintes - Niveau: S1; Se déplace avec les éléments voisins: no
Legrand_Plexo_vide | Legrand_Plexo_vide | Legrand_Plexo_vide | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7099383 | Installations électriques | Legrand_Plexo_vide | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081427 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_vide | Legrand_Plexo_vide | Contraintes - Niveau: S1; Se déplace avec les éléments voisins: no
Legrand_Plexo_composable_prise_FB_gris_069551L | Family | Legrand_Plexo_composable_prise_FB_gris_069551L | S1
Legrand_Plexo_composable_prise_FB_gris_069551L | Type | Legrand_Plexo_composable_prise_FB_gris_069551L | S1
Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091328 | Installations électriques | Legrand_Plexo_composable_prise_FB_gris_069551L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081481 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Données d'identification - GEM_ELE_NOM CIRCUIT: Q35; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Cotes - Volume: 0.0000777822 m3; Surface: 0.0152352 m2; Electricité - Charges - Panneau: TD1-Q35-BD2; Numero de circuit: 1; Charge: 100 VA; Electricité - Circuit - Données électriques: 250 V/1-100 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.8; Type de Revit - Fabricant: Legrand; Largeur: 0.0705 m; Profondeur: 0.046 m; Hauteur: 0.0705 m; Classe Etim: LC000125 Prise de courant; Réf legrand: LG-069551L; EAN: 3414971878792; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069551L-WEB-R.jpg; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 55; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m
9 x Legrand_Plexo_composable_prise_FB_gris_069551L | Instance | Legrand_Plexo_composable_prise_FB_gris_069551L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7081481 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Plexo_composable_prise_FB_gris_069551L | Autre - Nom de la famille: Legrand_Plexo_composable_prise_FB_gris_069551L; Classe Etim: LC000125 Prise de courant; Données d'identification - Nom du type: Legrand_Plexo_composable_prise_FB_gris_069551L; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.0705 m; Hauteur: 0.0705 m; Profondeur: 0.046 m; Electrique - Réf legrand: LG-069551L; EAN: 3414971878792; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069551L-WEB-R.jpg; Fabricant: Legrand; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 55; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Standard: FB
Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091329 | Installations électriques | Legrand_Plexo_composable_prise_FB_gris_069551L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081481 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Données d'identification - GEM_ELE_NOM CIRCUIT: Q35; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Cotes - Volume: 0.0000777822 m3; Surface: 0.0152352 m2; Electricité - Charges - Panneau: TD1-Q35-BD2; Numero de circuit: 1; Charge: 100 VA; Electricité - Circuit - Données électriques: 250 V/1-100 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.8; Type de Revit - Fabricant: Legrand; Largeur: 0.0705 m; Profondeur: 0.046 m; Hauteur: 0.0705 m; Classe Etim: LC000125 Prise de courant; Réf legrand: LG-069551L; EAN: 3414971878792; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069551L-WEB-R.jpg; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 55; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m
Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091528 | Installations électriques | Legrand_Plexo_composable_prise_FB_gris_069551L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081481 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Données d'identification - GEM_ELE_NOM CIRCUIT: Q35; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Cotes - Volume: 0.0000777822 m3; Surface: 0.0152352 m2; Electricité - Charges - Panneau: TD1-Q35-BD3; Numero de circuit: 1; Charge: 100 VA; Electricité - Circuit - Données électriques: 250 V/1-100 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.7; Type de Revit - Fabricant: Legrand; Largeur: 0.0705 m; Profondeur: 0.046 m; Hauteur: 0.0705 m; Classe Etim: LC000125 Prise de courant; Réf legrand: LG-069551L; EAN: 3414971878792; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069551L-WEB-R.jpg; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 55; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m
Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091529 | Installations électriques | Legrand_Plexo_composable_prise_FB_gris_069551L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081481 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Données d'identification - GEM_ELE_NOM CIRCUIT: Q35; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Cotes - Volume: 0.0000777822 m3; Surface: 0.0152352 m2; Electricité - Charges - Panneau: TD1-Q35-BD3; Numero de circuit: 1; Charge: 100 VA; Electricité - Circuit - Données électriques: 250 V/1-100 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.7; Type de Revit - Fabricant: Legrand; Largeur: 0.0705 m; Profondeur: 0.046 m; Hauteur: 0.0705 m; Classe Etim: LC000125 Prise de courant; Réf legrand: LG-069551L; EAN: 3414971878792; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069551L-WEB-R.jpg; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 55; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m
Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091548 | Installations électriques | Legrand_Plexo_composable_prise_FB_gris_069551L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081481 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Données d'identification - GEM_ELE_NOM CIRCUIT: Q35; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Cotes - Volume: 0.0000777822 m3; Surface: 0.0152352 m2; Electricité - Charges - Panneau: TD1-Q35-BD1; Numero de circuit: 1; Charge: 100 VA; Electricité - Circuit - Données électriques: 250 V/1-100 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.6; Type de Revit - Fabricant: Legrand; Largeur: 0.0705 m; Profondeur: 0.046 m; Hauteur: 0.0705 m; Classe Etim: LC000125 Prise de courant; Réf legrand: LG-069551L; EAN: 3414971878792; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069551L-WEB-R.jpg; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 55; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m
Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091549 | Installations électriques | Legrand_Plexo_composable_prise_FB_gris_069551L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081481 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Données d'identification - GEM_ELE_NOM CIRCUIT: Q35; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Cotes - Volume: 0.0000777822 m3; Surface: 0.0152352 m2; Electricité - Charges - Panneau: TD1-Q35-BD1; Numero de circuit: 1; Charge: 100 VA; Electricité - Circuit - Données électriques: 250 V/1-100 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.6; Type de Revit - Fabricant: Legrand; Largeur: 0.0705 m; Profondeur: 0.046 m; Hauteur: 0.0705 m; Classe Etim: LC000125 Prise de courant; Réf legrand: LG-069551L; EAN: 3414971878792; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069551L-WEB-R.jpg; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 55; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m
Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091556 | Installations électriques | Legrand_Plexo_composable_prise_FB_gris_069551L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081481 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Données d'identification - GEM_ELE_NOM CIRCUIT: Q34; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Cotes - Volume: 0.0000777822 m3; Surface: 0.0152352 m2; Electricité - Charges - Panneau: TD1-Q34-BD1; Numero de circuit: 1; Charge: 100 VA; Electricité - Circuit - Données électriques: 250 V/1-100 VA; Type de Revit - Fabricant: Legrand; Largeur: 0.0705 m; Profondeur: 0.046 m; Hauteur: 0.0705 m; Classe Etim: LC000125 Prise de courant; Réf legrand: LG-069551L; EAN: 3414971878792; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069551L-WEB-R.jpg; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 55; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m
Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7091557 | Installations électriques | Legrand_Plexo_composable_prise_FB_gris_069551L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081481 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Données d'identification - GEM_ELE_NOM CIRCUIT: Q34; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Cotes - Volume: 0.0000777822 m3; Surface: 0.0152352 m2; Electricité - Charges - Panneau: TD1-Q34-BD1; Numero de circuit: 1; Charge: 100 VA; Electricité - Circuit - Données électriques: 250 V/1-100 VA; Type de Revit - Fabricant: Legrand; Largeur: 0.0705 m; Profondeur: 0.046 m; Hauteur: 0.0705 m; Classe Etim: LC000125 Prise de courant; Réf legrand: LG-069551L; EAN: 3414971878792; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069551L-WEB-R.jpg; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 55; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m
Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7099382 | Installations électriques | Legrand_Plexo_composable_prise_FB_gris_069551L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7081481 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_composable_prise_FB_gris_069551L | Legrand_Plexo_composable_prise_FB_gris_069551L | Données d'identification - GEM_ELE_NOM CIRCUIT: Q34; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: S1; Cotes - Volume: 0.0000777822 m3; Surface: 0.0152352 m2; Electricité - Charges - Panneau: TD1-Q34-BD1; Numero de circuit: 1; Charge: 100 VA; Electricité - Circuit - Données électriques: 250 V/1-100 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.2; Type de Revit - Fabricant: Legrand; Largeur: 0.0705 m; Profondeur: 0.046 m; Hauteur: 0.0705 m; Classe Etim: LC000125 Prise de courant; Réf legrand: LG-069551L; EAN: 3414971878792; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069551L-WEB-R.jpg; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 55; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m
603_1POSTE_PLEXO | Family | 603_1POSTE_PLEXO | S1
PC 2P+T 230V | Type | PC 2P+T 230V | S1
603_1POSTE_PLEXO | PC 2P+T 230V | 603_1POSTE_PLEXO | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7099381 | Installations électriques | PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7099356 | 0.0011 | Installations électriques | 0 | Famille : Installations électriques : 603_1POSTE_PLEXO | 603_1POSTE_PLEXO | Contraintes - Niveau: S1; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Titre OmniClass: Electric Power and Lighting; Numéro OmniClass: 23.80.00.00; Module 1: Legrand_Plexo_composable_prise_FB_gris_069551L; Module 2: Legrand_Plexo_vide; Module 3: Legrand_Plexo_vide; Type de boite d'encastrement: Legrand_Plexo_vide; Boite d'encastrement: no; Type de boitier ou de support: Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L; CALC_DS: 0.0512 m
Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L | Family | Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L | S1
Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L | Type | Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L | S1
Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L | Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L | Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7099384 | Installations électriques | Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L | 0 | 2021_015 | yes | yes | Niveau : S1 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 7099174 | 1.2192 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L | Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L | Contraintes - Niveau: S1; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000803568 m3; Surface: 0.0241 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.2; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.057 m; Hauteur: 0.085 m; Classe Etim: LC000080 Boîtier en saillie; Réf legrand: LG-069651L; EAN: 3414971880863; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069651L-WEB-R.jpg; Sens de montage: Horizontal et vertical; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 57; IK: 08; Nombre de poste: 1
Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L | Instance | Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L | S1 | CurrentWithCentral | NotOwned | boulanger-mathe | 7099174 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L | Autre - Nom de la famille: Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L; Classe Etim: LC000080 Boîtier en saillie; Données d'identification - Nom du type: Legrand_Plexo_boitier_2_embouts_1_entrée_1_poste_gris_069651L; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.082 m; Hauteur: 0.085 m; Profondeur: 0.057 m; Electrique - Réf legrand: LG-069651L; EAN: 3414971880863; Conditions générales d'utilisation: https://export.legrand.com/CGU-objets-BIM; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LG-069651L-WEB-R.jpg; Fabricant: Legrand; Sens de montage: Horizontal et vertical; Couleur: Gris; Finition: Mat; RAL: 7046; IP: 57; IK: 08; Nombre de poste: 1
Luminaires | Category | Luminaires | <NoLevel>
604_DOWNLIGHT 200MM | Family | 604_DOWNLIGHT 200MM | <NoLevel>
18W | Type | 18W | <NoLevel>
604_DOWNLIGHT 200MM | 18W | 604_DOWNLIGHT 200MM | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 4485882 | Luminaires | 18W | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4668350 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_DOWNLIGHT 200MM | 604_DOWNLIGHT 200MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Élévation par rapport au niveau: 0 m; Cotes - Volume: 0.000644923 m3; Surface: 0.062157 m2; Electricité - Charges - Panneau: TD1-Q23-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-18 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.22; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_DOWNLIGHT 200MM | Instance | 604_DOWNLIGHT 200MM | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 4668350 | Luminaires |  |  | Famille : Luminaires : 604_DOWNLIGHT 200MM | Autre - Nom de la famille: 604_DOWNLIGHT 200MM; Données d'identification - Nom du type: 18W; Note d'identification: 600_ELECTRICITE C.FORTS; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0
Installations électriques | Category | Installations électriques | <NoLevel>
Legrand_Mosaic_plaque_8_mod_blanc_078818L | Family | Legrand_Mosaic_plaque_8_mod_blanc_078818L | <NoLevel>
Legrand_Mosaic_plaque_8_mod_blanc_078818L | Type | Legrand_Mosaic_plaque_8_mod_blanc_078818L | <NoLevel>
Legrand_Mosaic_plaque_8_mod_blanc_078818L | Legrand_Mosaic_plaque_8_mod_blanc_078818L | Legrand_Mosaic_plaque_8_mod_blanc_078818L | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 4824058 | Installations électriques | Legrand_Mosaic_plaque_8_mod_blanc_078818L | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1602412 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_8_mod_blanc_078818L | Legrand_Mosaic_plaque_8_mod_blanc_078818L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Cotes - Volume: 0.0000824185 m3; Surface: 0.0141779 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.224 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078818L; EAN: 3414971578036; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078818L-WEB-F.jpg; Nombre de modules horizontaux: 8; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04; Contraintes - Se déplace avec les éléments voisins: no
Legrand_Mosaic_plaque_8_mod_blanc_078818L | Instance | Legrand_Mosaic_plaque_8_mod_blanc_078818L | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 1602412 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_plaque_8_mod_blanc_078818L | Autre - Nom de la famille: Legrand_Mosaic_plaque_8_mod_blanc_078818L; Classe Etim: EC000007 Cadre de finition; Données d'identification - Nom du type: Legrand_Mosaic_plaque_8_mod_blanc_078818L; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.224 m; Hauteur: 0.082 m; Profondeur: 0.009 m; Electrique - Réf legrand: LG-078818L; EAN: 3414971578036; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078818L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 8; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Family | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | <NoLevel>
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Type | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | <NoLevel>
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 4824059 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q1; GEM_ELE_NOM TABLEAU: TD1; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q1-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
8 x Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Instance | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 682338 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Autre - Nom de la famille: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Classe Etim: EC000125 Prise de courant; Données d'identification - Nom du type: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Note d'identification: 600_ELECTRICITE C.FORTS; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.045 m; Hauteur: 0.045 m; Profondeur: 0.039 m; Electrique - Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 4824063 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q1; GEM_ELE_NOM TABLEAU: TD1; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q1-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 5798394 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q18; GEM_ELE_NOM TABLEAU: TD1; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q18-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
