Properties of the parts of a building model (IFC4), part 27 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6391369 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 515513 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Chemin de câbles - Courbure | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.79999 m; Cotes - Volume: 0.00618552 m3; Taille: 200 mmx50 mm-200 mmx50 mm; Rayon de courbure: 200 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 87.5775 deg; l: 200 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 368 mm; Libellé sur le rayon de courbure: 300 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6391370 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6391689 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 515513 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Chemin de câbles - Courbure | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.7 m; Cotes - Volume: 0.00621797 m3; Taille: 200 mmx50 mm-200 mmx50 mm; Rayon de courbure: 200 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 88.1974 deg; l: 200 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 371 mm; Libellé sur le rayon de courbure: 300 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698208 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6395857 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 515513 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Chemin de câbles - Courbure | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.45 m; Cotes - Volume: 0.0019716 m3; Taille: 100 mmx50 mm-100 mmx50 mm; Rayon de courbure: 100 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 89.5041 deg; l: 100 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 229 mm; Libellé sur le rayon de courbure: 150 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6395788 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6395860 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 515513 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Chemin de câbles - Courbure | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.45 m; Cotes - Volume: 0.0017141 m3; Taille: 200 mmx50 mm-200 mmx50 mm; Rayon de courbure: 200 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 2.17912 deg; l: 200 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 86 mm; Libellé sur le rayon de courbure: 300 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6395782 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6397243 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 515513 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Chemin de câbles - Courbure | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Cotes - Volume: 0.0017404 m3; Taille: 200 mmx50 mm-200 mmx50 mm; Rayon de courbure: 200 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 2.68136 deg; l: 200 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 87 mm; Libellé sur le rayon de courbure: 300 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6397136 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6397244 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 515513 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Chemin de câbles - Courbure | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Cotes - Volume: 0.00197704 m3; Taille: 100 mmx50 mm-100 mmx50 mm; Rayon de courbure: 100 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 89.92 deg; l: 100 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 230 mm; Libellé sur le rayon de courbure: 150 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6397142 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6517556 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 515513 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Chemin de câbles - Courbure | Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.45 m; Cotes - Volume: 0.000849962 m3; Taille: 100 mmx50 mm-100 mmx50 mm; Rayon de courbure: 200 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 2.29009 deg; l: 100 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 85 mm; Libellé sur le rayon de courbure: 250 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6517557 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6518690 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 515513 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Chemin de câbles - Courbure | Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Cotes - Volume: 0.00083065 m3; Taille: 100 mmx50 mm-100 mmx50 mm; Rayon de courbure: 100 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 2.3415 deg; l: 100 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 83 mm; Libellé sur le rayon de courbure: 150 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6518691 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Té | Family | Chemin de câbles - Té | N0
Chemin de câbles - Té | Standard | Chemin de câbles - Té | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698415 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 521743 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Té | Chemin de câbles - Té | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Cotes - Volume: 0.00505366 m3; Taille: 200 mmx50 mm-200 mmx50 mm-200 mmx50 mm; Epaisseur: 3 mm; Longueur de chemin: 50 mm; h: 50 mm; l1: 200 mm; Rayon: 50 mm; l3: 200 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Graphismes - Utiliser l'échelle d'annotations: no; Autre - Libellé de rayon: 50 mm; Libellé de rayon 1: 53 mm
2 x Chemin de câbles - Té | Instance | Chemin de câbles - Té | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698436 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Té | Autre - Nom de la famille: Chemin de câbles - Té; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Té | Standard | Chemin de câbles - Té | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4700798 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 521743 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Té | Chemin de câbles - Té | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.45 m; Cotes - Volume: 0.00505366 m3; Taille: 200 mmx50 mm-200 mmx50 mm-200 mmx50 mm; Epaisseur: 3 mm; Longueur de chemin: 50 mm; h: 50 mm; l1: 200 mm; Rayon: 50 mm; l3: 200 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; Graphismes - Utiliser l'échelle d'annotations: no; Autre - Libellé de rayon: 50 mm; Libellé de rayon 1: 53 mm
Chemin de câbles - Té | Standard | Chemin de câbles - Té | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6517546 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 521743 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Té | Chemin de câbles - Té | Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.45 m; Cotes - Volume: 0.00355366 m3; Taille: 200 mmx50 mm-200 mmx50 mm-100 mmx50 mm; Epaisseur: 3 mm; Longueur de chemin: 50 mm; h: 50 mm; l1: 200 mm; Rayon: 50 mm; l3: 100 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Graphismes - Utiliser l'échelle d'annotations: no; Autre - Libellé de rayon: 50 mm; Libellé de rayon 1: 53 mm
2 x Chemin de câbles - Té | Instance | Chemin de câbles - Té | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6517656 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Té | Autre - Nom de la famille: Chemin de câbles - Té; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Té | Standard | Chemin de câbles - Té | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6518604 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 521743 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Té | Chemin de câbles - Té | Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Cotes - Volume: 0.00355366 m3; Taille: 200 mmx50 mm-200 mmx50 mm-100 mmx50 mm; Epaisseur: 3 mm; Longueur de chemin: 50 mm; h: 50 mm; l1: 200 mm; Rayon: 50 mm; l3: 100 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Graphismes - Utiliser l'échelle d'annotations: no; Autre - Libellé de rayon: 50 mm; Libellé de rayon 1: 53 mm
Chemin de câbles - Courbure concave | Family | Chemin de câbles - Courbure concave | N0
Chemin de câbles - Courbure concave | Standard | Chemin de câbles - Courbure concave | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6391359 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 516848 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure concave | Chemin de câbles - Courbure concave | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.45 m; Cotes - Volume: 0.00326724 m3; Taille: 200 mmx50 mm-200 mmx50 mm; Rayon de courbure: 200 mm; Epaisseur: 3 mm; Longueur de chemin: 75 mm; Angle: 45.003 deg; l: 200 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 168 mm; Libellé sur le rayon de courbure: 225 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure concave | Instance | Chemin de câbles - Courbure concave | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6391360 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure concave | Autre - Nom de la famille: Chemin de câbles - Courbure concave; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure concave | Standard | Chemin de câbles - Courbure concave | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6391683 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 516848 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure concave | Chemin de câbles - Courbure concave | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Cotes - Volume: 0.00267808 m3; Taille: 200 mmx50 mm-200 mmx50 mm; Rayon de courbure: 200 mm; Epaisseur: 3 mm; Longueur de chemin: 75 mm; Angle: 30 deg; l: 200 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 135 mm; Libellé sur le rayon de courbure: 225 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure concave | Instance | Chemin de câbles - Courbure concave | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6391684 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure concave | Autre - Nom de la famille: Chemin de câbles - Courbure concave; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
TPFI-dévoiement de chemin de cable version 3 | Family | TPFI-dévoiement de chemin de cable version 3 | N0
Dévoiement de chemin de cable angle arrondi | Type | Dévoiement de chemin de cable angle arrondi | N0
TPFI-dévoiement de chemin de cable version 3 | Dévoiement de chemin de cable angle arrondi | TPFI-dévoiement de chemin de cable version 3 | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6394779 | Raccords de chemins de câbles | Dévoiement de chemin de cable angle arrondi | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 650907 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : TPFI-dévoiement de chemin de cable version 3 | TPFI-dévoiement de chemin de cable version 3 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.45 m; rayon de courbure_x: 0.1 m; hauteur de dévoiement: 0.116064 m; angle: 45 deg; longueur totale: 0.658012 m; largeur: 200 mm; hauteur: 50 mm; Cotes - Volume: 0.000543488 m3; Surface: 0.265124 m2; Rayon: 0.1 m; Taille: 200 mmx50 mm-200 mmx50 mm; Epaisseur: 3 mm; HD: 0.116064 m; alpha: 45 deg; Lt: 0.658012 m; LD: 0.198907 m; ld: 0.116064 m; adj: 0.0707107 m; y: 45 deg; opp: 0.0414214 m; longueur de dévoiement: 0 m; Type de Revit - Note d'identification: Basé sur modèle AutoDesk; Titre OmniClass: Air Ductwork; Numéro OmniClass: 23.75.70.14; Modèle: Raccord Union Male Gaine galva rectangulaire; angle droit: no; Angle arrondi: yes; extremité du dévoiement: no; épaisseur chemin de cable: 0.0025 m; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Graphismes - Utiliser l'échelle d'annotations: no; Texte - Modèle dévellopé par: David GRASSIN
2 x TPFI-dévoiement de chemin de cable version 3 | Instance | TPFI-dévoiement de chemin de cable version 3 | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6395235 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : TPFI-dévoiement de chemin de cable version 3 | Autre - Nom de la famille: TPFI-dévoiement de chemin de cable version 3; angle droit: no; Angle arrondi: yes; extremité du dévoiement: no; Données d'identification - Nom du type: Dévoiement de chemin de cable angle arrondi; Note d'identification: Basé sur modèle AutoDesk; Titre OmniClass: Air Ductwork; Numéro OmniClass: 23.75.70.14; Modèle: Raccord Union Male Gaine galva rectangulaire; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - épaisseur chemin de cable: 0.0025 m
TPFI-dévoiement de chemin de cable version 3 | Dévoiement de chemin de cable angle arrondi | TPFI-dévoiement de chemin de cable version 3 | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6395901 | Raccords de chemins de câbles | Dévoiement de chemin de cable angle arrondi | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 650907 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : TPFI-dévoiement de chemin de cable version 3 | TPFI-dévoiement de chemin de cable version 3 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; rayon de courbure_x: 0.1 m; hauteur de dévoiement: 0.116064 m; angle: 45 deg; longueur totale: 0.658012 m; largeur: 200 mm; hauteur: 50 mm; Cotes - Volume: 0.000543488 m3; Surface: 0.265124 m2; Rayon: 0.1 m; Taille: 200 mmx50 mm-200 mmx50 mm; Epaisseur: 3 mm; HD: 0.116064 m; alpha: 45 deg; Lt: 0.658012 m; LD: 0.198907 m; ld: 0.116064 m; adj: 0.0707107 m; y: 45 deg; opp: 0.0414214 m; longueur de dévoiement: 0 m; Type de Revit - Note d'identification: Basé sur modèle AutoDesk; Titre OmniClass: Air Ductwork; Numéro OmniClass: 23.75.70.14; Modèle: Raccord Union Male Gaine galva rectangulaire; angle droit: no; Angle arrondi: yes; extremité du dévoiement: no; épaisseur chemin de cable: 0.0025 m; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Graphismes - Utiliser l'échelle d'annotations: no; Texte - Modèle dévellopé par: David GRASSIN
Chemin de câbles - Réduction | Family | Chemin de câbles - Réduction | N0
Chemin de câbles - Réduction | Standard | Chemin de câbles - Réduction | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6395858 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 520799 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Réduction | Chemin de câbles - Réduction | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.45 m; Cotes - Volume: 0.001125 m3; Surface: 0.0105178 m2; Taille: 200 mmx50 mm-100 mmx50 mm; Epaisseur: 3 mm; Longueur de chemin: 150 mm; l1: 100 mm; Hauteur de décalage: 25.0000 mm; Largeur de décalage: 0.0000 mm; h1: 50 mm; l2: 200 mm; h2: 50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Graphismes - Utiliser l'échelle d'annotations: no; Autre - Longueur 1: 3048 mm; Décalage de la largeur: 2998 mm; Décalage de la hauteur: 3048 mm; Décalage horizontal du profil: -50 mm; Décalage vertical du profil: 0 mm
2 x Chemin de câbles - Réduction | Instance | Chemin de câbles - Réduction | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6395859 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Réduction | Autre - Nom de la famille: Chemin de câbles - Réduction; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Réduction | Standard | Chemin de câbles - Réduction | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6397245 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 520799 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Réduction | Chemin de câbles - Réduction | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Cotes - Volume: 0.001125 m3; Surface: 0.0105178 m2; Taille: 200 mmx50 mm-100 mmx50 mm; Epaisseur: 3 mm; Longueur de chemin: 150 mm; l1: 100 mm; Hauteur de décalage: 25.0000 mm; Largeur de décalage: 0.0000 mm; h1: 50 mm; l2: 200 mm; h2: 50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Graphismes - Utiliser l'échelle d'annotations: no; Autre - Longueur 1: 3048 mm; Décalage de la largeur: 2998 mm; Décalage de la hauteur: 3048 mm; Décalage horizontal du profil: -50 mm; Décalage vertical du profil: 0 mm
Installations électriques | Category | Installations électriques | N0
603_DETECTEUR PD4-M-1C-C-PS | Family | 603_DETECTEUR PD4-M-1C-C-PS | N0
CATALOGUE DE TYPE | Type | CATALOGUE DE TYPE | N0
603_DETECTEUR PD4-M-1C-C-PS | CATALOGUE DE TYPE | 603_DETECTEUR PD4-M-1C-C-PS | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 5548988 | Installations électriques | CATALOGUE DE TYPE | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5044805 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_DETECTEUR PD4-M-1C-C-PS | 603_DETECTEUR PD4-M-1C-C-PS | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Identifiant: 2; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Niveau de nomenclature: N0; ZZZ_X_Length: 0.0505 m; ZZZ_Y_Length: 0.0505 m; ZZZ_Suspension_height_02_Length: 0 m; ZZZ_Logo LOD400_YesNo: no; ZZZ_Logo LOD200_YesNo: yes; ZZZ_Suspension_height_03_Length: 0 m; ZZZ_SOg_3D_gen_YesNo: no; ZZZ_Suspension_height_01_Length: 0 m; ZZZ_Detection zone_3D_type_FamilyType_Lighting Devices: standard; Cotes - Volume: 0.00946941 m3; Surface: 0.468618 m2; Electricité - Charges - Panneau: TD1-Q23-BD7; Numero de circuit: 2; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.16; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: MOVEMENTSENSOR; Fabricant: B.E.G.; Modèle: capteur de mouvement; URL: -; Description: capteur de mouvement; Exporter le type au format IFC sous: IfcAirTerminalType; Couleur: -; Code d'assemblage: 62.60.10; IfcExportAs: IfcAirTerminalType; IfcExportType: MOVEMENTSENSOR; RSen_C_content_date_issue: 29/09/2023; ZZZ_Cut out_X_Length: 0 m; ZZZ_Logo_Z_Length: 0 m; ZZZ_Height_Width_Length: 0.076 m; ZZZ_Width_Length: 0.101 m; ZZZ_Suspension_YesNo: no; ZZZ_Cut out_Y_Length: 0 m; ZZZ_Const_06_Length: 0 m; ZZZ_Width_Height_Length: 0.101 m; ZZZ_Recessed_YesNo: no; ZZZ_Cut out_length_Length: 0 m; ZZZ_Const_05_Length: 0 m; ZZZ_Parallel wall mounted_YesNo: no; ZZZ_Const_04_Length: 0 m; ZZZ_Logo_plane_Integer: 2; ZZZ_Detection zone_rotation_Angle: 0 deg; ZZZ_Mounted_ceiling_YesNo: no; ZZZ_Logo_Y_Length: 0 m; ZZZ_Cut out_length__Length: 0.001 m; ZZZ_Detection zone_X_Length: 0 m; ZZZ_Cut out_height_Length: 0 m; ZZZ_Cut out_width__Length: 0.001 m; ZZZ_Pendant - vertical mounted_YesNo: no; ZZZ_Logo_X_Length: 0 m; ZZZ_Zones_plane_Integer: 2; ZZZ_Cut out_width_Length: 0 m; ZZZ_Const_03_Length: 0 m; ZZZ_Displacement_Y_Length: 0 m; ZZZ_Height negative_Length: -0.076 m; ZZZ_Height_Length: 0.076 m; ZZZ_Detection zone_plane_Integer: 1; ZZZ_Detection zone_Z_Length: 0 m; ZZZ_Pendant - horizontal mounted_YesNo: no; ZZZ_Logo_Rotation about axis_Angle: 180 deg; ZZZ_Cut out_diameter_Length: 0 m; ZZZ_Surface mounted_YesNo: yes; ZZZ_IP_YesNo: no; ZZZ_Recess depth_Length: 0 m; ZZZ_Mounted_wall_YesNo: yes; ZZZ_Angled wall mounted_YesNo: no; ZZZ_Cut out_radius_Length: 0.001 m; ZZZ_Detection zone_Y_Length: 0 m; ZZZ_Cut out_height negative_Length: -0.002 m; ZZZ_Const_01_Length: 0 m; ZZZ_Length_Length: 0.101 m; ZZZ_Const_02_Length: 0 m; ZZZ_Placeholder for SOg_FamilyType_Lighting Devices: aucun; ZZZ_Detection zone_3D_standard_FamilyType_Lighting Devices: standard; ZZZ_Visualized connectors_FamilyType_Generic Models: standard; ZZZ_Detection zone_3D_none_FamilyType_Lighting Devices: standard; ZZZ_Bounding Box_FamilyType_Lighting Devices: standard; ZZZ_Annotation_FamilyType_Generic Annotations: standard; ZZZ_V Component_02_X_Length: 0 m; ZZZ_V Component_01_width_Length: 0 m; ZZZ_V E_c01_Z_Length: 0 m; ZZZ_V Component_03_width_Length: 0 m; ZZZ_V Clearance zone_bottom_Length: 0 m; ZZZ_V Component_03_Y_Length: 0 m; ZZZ_V Component_01_Z_Length: 0 m; ZZZ_V Component_03_length_Length: 0 m; ZZZ_V Component_03_height_Length: 0 m; ZZZ_V Clearance zone_top_Length: 0 m; ZZZ_V Light sensor_YesNo: no; ZZZ_V E_c01_Y_Length: 0 m; ZZZ_V Detection range at height_Length: 2.5 m; ZZZ_V Detection range_02_max height_Length: 5 m; ZZZ_V Suspension_plane_Integer: 2; ZZZ_V Component_01_plane_Integer: 1; ZZZ_V Component_03_diameter_Length: 0 m; ZZZ_V SOg_plane_Integer: 2; ZZZ_V Component_02_width_Length: 0 m; ZZZ_V Detection zone_03_material_Material: RSfr_x_rgb 000 128 000 T80 vert_gen; ZZZ_V Clearance zone_material_Material: RSfr_x_rgb 255 128 128 T80 rouge_gen; ZZZ_V Detection angle_Angle: 360 deg; ZZZ_V Detection range_01_Length: 40 m; ZZZ_V Component_02_Z_Length: 0 m; ZZZ_V SOg_X_Length: 0 m; ZZZ_V Component_03_Z_Length: 0 m; ZZZ_V Clearance zone_right_Length: 0 m; ZZZ_V SOg_Y_Length: 0 m; ZZZ_V Component_01_length_Length: 0 m; ZZZ_V Ventilation control_YesNo: no; ZZZ_V Component_03_plane_Integer: 1; ZZZ_V Component_01_height_Length: 0.076 m; ZZZ_V Suspension_Y_Length: 0 m; ZZZ_V Component_02_Y_Length: 0 m; ZZZ_V IP_Integer: 0; ZZZ_V Component_01_X_Length: 0 m; ZZZ_V E_c01_plane_Integer: 1; ZZZ_V Detection range_01_max height_Length: 5 m; ZZZ_V Component_02_length_Length: 0 m; ZZZ_V Detection range_03_max height_Length: 3.5 m; ZZZ_V Component_02_height_Length: 0 m; ZZZ_V E_c01_X_Length: 0 m; ZZZ_V Clearance zone_back_Length: 0 m; ZZZ_V Clearance zone_front_Length: 0 m; ZZZ_V Detection range_03_Length: 5 m; ZZZ_V Component_03_X_Length: 0 m; ZZZ_V Component_02_description_Text: -; ZZZ_V Detection range_02_Length: 7 m; ZZZ_V Component_02_diameter_Length: 0 m; ZZZ_V SOg_rotation_Angle: 0 deg; ZZZ_V Suspension_offset_Length: 0 m; ZZZ_V Suspension_width_Length: 0 m; ZZZ_V Component_01_diameter_Length: 0.101 m; ZZZ_V Dimmer_YesNo: no; ZZZ_V Component_03_description_Text: -; ZZZ_V SOg_Z_Length: 0 m; ZZZ_V Suspension_X_Length: 0 m; ZZZ_V Component_02_plane_Integer: 2; ZZZ_V Suspension_min_Length: 0 m; ZZZ_V Detection zone_02_material_Material: RSfr_x_rgb 000 128 255 T80 bleu_gen; ZZZ_V Component_01_description_Text: détecteur; ZZZ_V Suspension_max_Length: 0 m; ZZZ_V Component_01_Y_Length: 0 m; ZZZ_V Detection zone_01_material_Material: RSfr_x_rgb 255 128 128 T80 rouge_gen; ZZZ_V Clearance zone_left_Length: 0 m; ZZZ_V Suspension_length_Length: 0 m; ZZZ_V Suspension_type_FamilyType_Lighting Devices: aucun_gen; RSfr_C_type: capteur de mouvement; RSfr_C_content_version: 1.0.0; RSfr_C_revit_version: 2020; TBQfr_C_licence_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; RSfr_C_code_gtin: -; RSfr_C_type_commentaires: capteur de mouvement; RSfr_C_code_ETIM_url: http://prod.etim-international.com/; RSfr_C_content_date_modifié: 29/09/2023; TBQfr_C_code_produit: -; RSfr_C_content_fournisseur: B.E.G.; RSfr_C_content_créateur: © ThorbiQ; RSfr_C_description: capteur de mouvement; RSfr_C_code_article: -; TBQfr_C_IFC_version: 2x3; RSfr_C_code_classe_de_produit: -; RSfr_C_modèle: capteur de mouvement; TBQfr_C_licence: Creative Commons Attribution NoDerivs (CC-ND); RSfr_C_largeur: 0 m; RSfr_C_hauteur: 0.076 m; TBQfr_C_SOg_LD_2D: aucun; TBQfr_C_accessoires_EE_02: aucun_gen; TBQfr_C_accessoires_EE_05: aucun_gen; RSfr_E_c01_puissance_apparente: 0 VA; RSfr_E_c01_nombre_de_pôles: 1; TBQfr_C_accessoires_EE_03: aucun_gen; RSfr_C_longueur: 0 m; RSfr_E_c01_tension: 230 V; TBQfr_E_c01_oui_non: yes; TBQfr_C_SOg_LD_3D: aucun; TBQfr_C_accessoires_EE_04: aucun_gen; RSfr_C_diamètre: 0.101 m; RSfr_E_c01_sous_indice_de_charge_moteur: no; TBQfr_C_accessoire_01_description: -; RSfr_E_c01_description: -; TBQfr_E_c01_type_de_système: -; TBQ_I BaseKeynote: 62.60.10; TBQ_I Domaine de saisie des données: -; TBQ_I Maître: yes; TBQ_I Esclave: no; TBQ_I Type de sortie: -; Scénario: -; Dimensions du bloc d'alimentation externe: -; Puissance interne W: -; Absorption de courant mA: -; Réglages: -; Surface contrôlée approche tangentielle m² à une hauteur de montage de 2,5 m: -; Hauteur de montage Min. m: -; Hauteur de montage Max. m: -; Hauteur de montage Recommandé m: -; Mesurage du lumière: -; Évaluation de la température: -; Boîtier: -; Longeur de cable cm: -; KNX Nombre de capteurs de luminosité: -; KNX Nombre de capteurs PIR: -; KNX TP 256: -; Canal 01: -; Canal 01 Puissance: -; Canal 01 Lumière d’orientation: -; Canal 01 Nachtlicht: -; Canal 02: -; Canal 02 Puissance: -; Canal 02 Durée de temporisation: -; Canal 02 Lumière d’orientation: -; Canal 02 Seuil d´enchlenchement Lux: -; Détecteur Largeur en mm: -; Détecteur Hauteur en mm: -; Détecteur Profondeur en mm: -; Graphismes - ZZZ_V Position annotation x_Integer: 0; ZZZ_V Position annotation y_Integer: 0; ZZZ_V Displacement annotation y_Length: 0 m; ZZZ_V Displacement annotation x_Length: 0 m; TBQfr_C_zone_libre: no; TBQfr_C_portée_02_description: Frontale; TBQfr_C_portée_01_description: Transversale; TBQfr_C_logo: yes; TBQfr_C_portée_01: no; TBQfr_C_portée_02: no; TBQfr_C_portée_03_description: Activité assise; TBQfr_C_portée_03: no; Construction - ZZZ_V Suspension_height_Length: 0 m; TBQfr_C_alignement: Centre; TBQfr_C_GOg: yes; TBQfr_C_accessoires_EE_01: aucun_gen; TBQfr_C_alignement_index: 0; TBQfr_C_SOg: no; TBQfr_C_hauteur_de_montage: 2.5 m; Electrique - TBQfr_E_facteur_de_puissance: 1; TBQfr_E_c01_facteur_de_puissance: 1; RSfr_E_c01_indice_de_charge: Other
2 x 603_DETECTEUR PD4-M-1C-C-PS | Instance | 603_DETECTEUR PD4-M-1C-C-PS | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 5044805 | Installations électriques |  |  | Famille : Installations électriques : 603_DETECTEUR PD4-M-1C-C-PS | Autre - Nom de la famille: 603_DETECTEUR PD4-M-1C-C-PS; ZZZ_V E_c01_Z_Length: 0 m; ZZZ_V E_c01_Y_Length: 0 m; ZZZ_V E_c01_plane_Integer: 1; ZZZ_V E_c01_X_Length: 0 m; TBQfr_E_c01_oui_non: yes; RSfr_E_c01_description: -; TBQfr_E_c01_type_de_système: -; Données d'identification - Nom du type: CATALOGUE DE TYPE; Note d'identification: 600_ELECTRICITE C.FORTS; Modèle: capteur de mouvement; Fabricant: B.E.G.; URL: -; Description: capteur de mouvement; Code d'assemblage: 62.60.10; RSen_C_content_date_issue: 29/09/2023; RSfr_C_type: capteur de mouvement; RSfr_C_content_version: 1.0.0; RSfr_C_revit_version: 2020; TBQfr_C_licence_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; RSfr_C_code_gtin: -; RSfr_C_type_commentaires: capteur de mouvement; RSfr_C_code_ETIM_url: http://prod.etim-international.com/; RSfr_C_content_date_modifié: 29/09/2023; TBQfr_C_code_produit: -; RSfr_C_content_fournisseur: B.E.G.; RSfr_C_content_créateur: © ThorbiQ; RSfr_C_description: capteur de mouvement; RSfr_C_code_article: -; TBQfr_C_IFC_version: 2x3; RSfr_C_code_classe_de_produit: -; RSfr_C_modèle: capteur de mouvement; TBQfr_C_licence: Creative Commons Attribution NoDerivs (CC-ND); TBQfr_C_accessoire_01_description: -; TBQ_I BaseKeynote: 62.60.10; Contraintes - Elévation par défaut: 0 m; ZZZ_Cut out_X_Length: 0 m; ZZZ_Logo_Z_Length: 0 m; ZZZ_Height_Width_Length: 0.076 m; ZZZ_Width_Length: 0.101 m; ZZZ_Suspension_YesNo: no; ZZZ_Cut out_Y_Length: 0 m; ZZZ_Const_06_Length: 0 m; ZZZ_Width_Height_Length: 0.101 m; ZZZ_Recessed_YesNo: no; ZZZ_Cut out_length_Length: 0 m; ZZZ_Const_05_Length: 0 m; ZZZ_Parallel wall mounted_YesNo: no; ZZZ_Const_04_Length: 0 m; ZZZ_Logo_plane_Integer: 2; ZZZ_Detection zone_rotation_Angle: 0 deg; ZZZ_Mounted_ceiling_YesNo: no; ZZZ_Logo_Y_Length: 0 m; ZZZ_Cut out_length__Length: 0.001 m; ZZZ_Detection zone_X_Length: 0 m; ZZZ_Cut out_height_Length: 0 m; ZZZ_Cut out_width__Length: 0.001 m; ZZZ_Pendant - vertical mounted_YesNo: no; ZZZ_Logo_X_Length: 0 m; ZZZ_Zones_plane_Integer: 2; ZZZ_Cut out_width_Length: 0 m; ZZZ_Const_03_Length: 0 m; ZZZ_Displacement_Y_Length: 0 m; ZZZ_Height negative_Length: -0.076 m; ZZZ_Height_Length: 0.076 m; ZZZ_Detection zone_plane_Integer: 1; ZZZ_Detection zone_Z_Length: 0 m; ZZZ_Pendant - horizontal mounted_YesNo: no; ZZZ_Logo_Rotation about axis_Angle: 180 deg; ZZZ_Cut out_diameter_Length: 0 m; ZZZ_Surface mounted_YesNo: yes; ZZZ_IP_YesNo: no; ZZZ_Recess depth_Length: 0 m; ZZZ_Mounted_wall_YesNo: yes; ZZZ_Angled wall mounted_YesNo: no; ZZZ_Cut out_radius_Length: 0.001 m; ZZZ_Detection zone_Y_Length: 0 m; ZZZ_Cut out_height negative_Length: -0.002 m; ZZZ_Const_01_Length: 0 m; ZZZ_Length_Length: 0.101 m; ZZZ_Const_02_Length: 0 m; ZZZ_Placeholder for SOg_FamilyType_Lighting Devices: aucun; ZZZ_Detection zone_3D_standard_FamilyType_Lighting Devices: standard; ZZZ_Visualized connectors_FamilyType_Generic Models: standard; ZZZ_Detection zone_3D_none_FamilyType_Lighting Devices: standard; ZZZ_Bounding Box_FamilyType_Lighting Devices: standard; ZZZ_Annotation_FamilyType_Generic Annotations: standard; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: MOVEMENTSENSOR; Exporter le type au format IFC sous: IfcAirTerminalType; IfcExportAs: IfcAirTerminalType; IfcExportType: MOVEMENTSENSOR; Construction - ZZZ_V Component_02_X_Length: 0 m; ZZZ_V Component_01_width_Length: 0 m; ZZZ_V Component_03_width_Length: 0 m; ZZZ_V Component_03_Y_Length: 0 m; ZZZ_V Component_01_Z_Length: 0 m; ZZZ_V Component_03_length_Length: 0 m; ZZZ_V Component_03_height_Length: 0 m; ZZZ_V Suspension_plane_Integer: 2; ZZZ_V Component_01_plane_Integer: 1; ZZZ_V Component_03_diameter_Length: 0 m; ZZZ_V SOg_plane_Integer: 2; ZZZ_V Component_02_width_Length: 0 m; ZZZ_V Component_02_Z_Length: 0 m; ZZZ_V SOg_X_Length: 0 m; ZZZ_V Component_03_Z_Length: 0 m; ZZZ_V SOg_Y_Length: 0 m; ZZZ_V Component_01_length_Length: 0 m; ZZZ_V Component_03_plane_Integer: 1; ZZZ_V Component_01_height_Length: 0.076 m; ZZZ_V Suspension_Y_Length: 0 m; ZZZ_V Component_02_Y_Length: 0 m; ZZZ_V Component_01_X_Length: 0 m; ZZZ_V Component_02_length_Length: 0 m; ZZZ_V Component_02_height_Length: 0 m; ZZZ_V Component_03_X_Length: 0 m; ZZZ_V Component_02_description_Text: -; ZZZ_V Component_02_diameter_Length: 0 m; ZZZ_V SOg_rotation_Angle: 0 deg; ZZZ_V Suspension_offset_Length: 0 m; ZZZ_V Suspension_width_Length: 0 m; ZZZ_V Component_01_diameter_Length: 0.101 m; ZZZ_V Component_03_description_Text: -; ZZZ_V SOg_Z_Length: 0 m; ZZZ_V Suspension_X_Length: 0 m; ZZZ_V Component_02_plane_Integer: 2; ZZZ_V Component_01_description_Text: détecteur; ZZZ_V Component_01_Y_Length: 0 m; ZZZ_V Suspension_length_Length: 0 m; ZZZ_V Suspension_type_FamilyType_Lighting Devices: aucun_gen; TBQfr_C_SOg_LD_2D: aucun; TBQfr_C_accessoires_EE_02: aucun_gen; TBQfr_C_accessoires_EE_05: aucun_gen; TBQfr_C_accessoires_EE_03: aucun_gen; TBQfr_C_SOg_LD_3D: aucun; TBQfr_C_accessoires_EE_04: aucun_gen; Graphismes - ZZZ_V Clearance zone_bottom_Length: 0 m; ZZZ_V Clearance zone_top_Length: 0 m; ZZZ_V Clearance zone_right_Length: 0 m; ZZZ_V Clearance zone_back_Length: 0 m; ZZZ_V Clearance zone_front_Length: 0 m; ZZZ_V Clearance zone_left_Length: 0 m; Propriétés du modèle - ZZZ_V Light sensor_YesNo: no; ZZZ_V Detection range at height_Length: 2.5 m; ZZZ_V Detection range_02_max height_Length: 5 m; ZZZ_V Detection angle_Angle: 360 deg; ZZZ_V Detection range_01_Length: 40 m; ZZZ_V Ventilation control_YesNo: no; ZZZ_V IP_Integer: 0; ZZZ_V Detection range_01_max height_Length: 5 m; ZZZ_V Detection range_03_max height_Length: 3.5 m; ZZZ_V Detection range_03_Length: 5 m; ZZZ_V Detection range_02_Length: 7 m; ZZZ_V Dimmer_YesNo: no; ZZZ_V Suspension_min_Length: 0 m; ZZZ_V Suspension_max_Length: 0 m; TBQ_I Domaine de saisie des données: -; TBQ_I Maître: yes; TBQ_I Esclave: no; TBQ_I Type de sortie: -; Scénario: -; Couleur: -; Dimensions du bloc d'alimentation externe: -; Puissance interne W: -; Absorption de courant mA: -; Réglages: -; Surface contrôlée approche tangentielle m² à une hauteur de montage de 2,5 m: -; Hauteur de montage Min. m: -; Hauteur de montage Max. m: -; Hauteur de montage Recommandé m: -; Mesurage du lumière: -; Évaluation de la température: -; Boîtier: -; Longeur de cable cm: -; KNX Nombre de capteurs de luminosité: -; KNX Nombre de capteurs PIR: -; KNX TP 256: -; Canal 01: -; Canal 01 Puissance: -; Canal 01 Lumière d’orientation: -; Canal 01 Nachtlicht: -; Canal 02: -; Canal 02 Puissance: -; Canal 02 Durée de temporisation: -; Canal 02 Lumière d’orientation: -; Canal 02 Seuil d´enchlenchement Lux: -; Détecteur Largeur en mm: -; Détecteur Hauteur en mm: -; Détecteur Profondeur en mm: -; Matériaux et finitions - ZZZ_V Detection zone_03_material_Material: RSfr_x_rgb 000 128 000 T80 vert_gen; ZZZ_V Clearance zone_material_Material: RSfr_x_rgb 255 128 128 T80 rouge_gen; ZZZ_V Detection zone_02_material_Material: RSfr_x_rgb 000 128 255 T80 bleu_gen; ZZZ_V Detection zone_01_material_Material: RSfr_x_rgb 255 128 128 T80 rouge_gen; Cotes - RSfr_C_largeur: 0 m; RSfr_C_hauteur: 0.076 m; RSfr_C_longueur: 0 m; RSfr_C_diamètre: 0.101 m; Electrique - RSfr_E_c01_puissance_apparente: 0 VA; RSfr_E_c01_nombre_de_pôles: 1; RSfr_E_c01_tension: 230 V; RSfr_E_c01_sous_indice_de_charge_moteur: no
603_DETECTEUR PD4-M-1C-C-PS | CATALOGUE DE TYPE | 603_DETECTEUR PD4-M-1C-C-PS | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 5549460 | Installations électriques | CATALOGUE DE TYPE | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5044805 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_DETECTEUR PD4-M-1C-C-PS | 603_DETECTEUR PD4-M-1C-C-PS | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Identifiant: 3; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Niveau de nomenclature: N0; ZZZ_X_Length: 0.0505 m; ZZZ_Y_Length: 0.0505 m; ZZZ_Suspension_height_02_Length: 0 m; ZZZ_Logo LOD400_YesNo: no; ZZZ_Logo LOD200_YesNo: yes; ZZZ_Suspension_height_03_Length: 0 m; ZZZ_SOg_3D_gen_YesNo: no; ZZZ_Suspension_height_01_Length: 0 m; ZZZ_Detection zone_3D_type_FamilyType_Lighting Devices: standard; Cotes - Volume: 0.00946941 m3; Surface: 0.468618 m2; Electricité - Charges - Panneau: TD1-Q23-BD6; Numero de circuit: 2; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.17; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: MOVEMENTSENSOR; Fabricant: B.E.G.; Modèle: capteur de mouvement; URL: -; Description: capteur de mouvement; Exporter le type au format IFC sous: IfcAirTerminalType; Couleur: -; Code d'assemblage: 62.60.10; IfcExportAs: IfcAirTerminalType; IfcExportType: MOVEMENTSENSOR; RSen_C_content_date_issue: 29/09/2023; ZZZ_Cut out_X_Length: 0 m; ZZZ_Logo_Z_Length: 0 m; ZZZ_Height_Width_Length: 0.076 m; ZZZ_Width_Length: 0.101 m; ZZZ_Suspension_YesNo: no; ZZZ_Cut out_Y_Length: 0 m; ZZZ_Const_06_Length: 0 m; ZZZ_Width_Height_Length: 0.101 m; ZZZ_Recessed_YesNo: no; ZZZ_Cut out_length_Length: 0 m; ZZZ_Const_05_Length: 0 m; ZZZ_Parallel wall mounted_YesNo: no; ZZZ_Const_04_Length: 0 m; ZZZ_Logo_plane_Integer: 2; ZZZ_Detection zone_rotation_Angle: 0 deg; ZZZ_Mounted_ceiling_YesNo: no; ZZZ_Logo_Y_Length: 0 m; ZZZ_Cut out_length__Length: 0.001 m; ZZZ_Detection zone_X_Length: 0 m; ZZZ_Cut out_height_Length: 0 m; ZZZ_Cut out_width__Length: 0.001 m; ZZZ_Pendant - vertical mounted_YesNo: no; ZZZ_Logo_X_Length: 0 m; ZZZ_Zones_plane_Integer: 2; ZZZ_Cut out_width_Length: 0 m; ZZZ_Const_03_Length: 0 m; ZZZ_Displacement_Y_Length: 0 m; ZZZ_Height negative_Length: -0.076 m; ZZZ_Height_Length: 0.076 m; ZZZ_Detection zone_plane_Integer: 1; ZZZ_Detection zone_Z_Length: 0 m; ZZZ_Pendant - horizontal mounted_YesNo: no; ZZZ_Logo_Rotation about axis_Angle: 180 deg; ZZZ_Cut out_diameter_Length: 0 m; ZZZ_Surface mounted_YesNo: yes; ZZZ_IP_YesNo: no; ZZZ_Recess depth_Length: 0 m; ZZZ_Mounted_wall_YesNo: yes; ZZZ_Angled wall mounted_YesNo: no; ZZZ_Cut out_radius_Length: 0.001 m; ZZZ_Detection zone_Y_Length: 0 m; ZZZ_Cut out_height negative_Length: -0.002 m; ZZZ_Const_01_Length: 0 m; ZZZ_Length_Length: 0.101 m; ZZZ_Const_02_Length: 0 m; ZZZ_Placeholder for SOg_FamilyType_Lighting Devices: aucun; ZZZ_Detection zone_3D_standard_FamilyType_Lighting Devices: standard; ZZZ_Visualized connectors_FamilyType_Generic Models: standard; ZZZ_Detection zone_3D_none_FamilyType_Lighting Devices: standard; ZZZ_Bounding Box_FamilyType_Lighting Devices: standard; ZZZ_Annotation_FamilyType_Generic Annotations: standard; ZZZ_V Component_02_X_Length: 0 m; ZZZ_V Component_01_width_Length: 0 m; ZZZ_V E_c01_Z_Length: 0 m; ZZZ_V Component_03_width_Length: 0 m; ZZZ_V Clearance zone_bottom_Length: 0 m; ZZZ_V Component_03_Y_Length: 0 m; ZZZ_V Component_01_Z_Length: 0 m; ZZZ_V Component_03_length_Length: 0 m; ZZZ_V Component_03_height_Length: 0 m; ZZZ_V Clearance zone_top_Length: 0 m; ZZZ_V Light sensor_YesNo: no; ZZZ_V E_c01_Y_Length: 0 m; ZZZ_V Detection range at height_Length: 2.5 m; ZZZ_V Detection range_02_max height_Length: 5 m; ZZZ_V Suspension_plane_Integer: 2; ZZZ_V Component_01_plane_Integer: 1; ZZZ_V Component_03_diameter_Length: 0 m; ZZZ_V SOg_plane_Integer: 2; ZZZ_V Component_02_width_Length: 0 m; ZZZ_V Detection zone_03_material_Material: RSfr_x_rgb 000 128 000 T80 vert_gen; ZZZ_V Clearance zone_material_Material: RSfr_x_rgb 255 128 128 T80 rouge_gen; ZZZ_V Detection angle_Angle: 360 deg; ZZZ_V Detection range_01_Length: 40 m; ZZZ_V Component_02_Z_Length: 0 m; ZZZ_V SOg_X_Length: 0 m; ZZZ_V Component_03_Z_Length: 0 m; ZZZ_V Clearance zone_right_Length: 0 m; ZZZ_V SOg_Y_Length: 0 m; ZZZ_V Component_01_length_Length: 0 m; ZZZ_V Ventilation control_YesNo: no; ZZZ_V Component_03_plane_Integer: 1; ZZZ_V Component_01_height_Length: 0.076 m; ZZZ_V Suspension_Y_Length: 0 m; ZZZ_V Component_02_Y_Length: 0 m; ZZZ_V IP_Integer: 0; ZZZ_V Component_01_X_Length: 0 m; ZZZ_V E_c01_plane_Integer: 1; ZZZ_V Detection range_01_max height_Length: 5 m; ZZZ_V Component_02_length_Length: 0 m; ZZZ_V Detection range_03_max height_Length: 3.5 m; ZZZ_V Component_02_height_Length: 0 m; ZZZ_V E_c01_X_Length: 0 m; ZZZ_V Clearance zone_back_Length: 0 m; ZZZ_V Clearance zone_front_Length: 0 m; ZZZ_V Detection range_03_Length: 5 m; ZZZ_V Component_03_X_Length: 0 m; ZZZ_V Component_02_description_Text: -; ZZZ_V Detection range_02_Length: 7 m; ZZZ_V Component_02_diameter_Length: 0 m; ZZZ_V SOg_rotation_Angle: 0 deg; ZZZ_V Suspension_offset_Length: 0 m; ZZZ_V Suspension_width_Length: 0 m; ZZZ_V Component_01_diameter_Length: 0.101 m; ZZZ_V Dimmer_YesNo: no; ZZZ_V Component_03_description_Text: -; ZZZ_V SOg_Z_Length: 0 m; ZZZ_V Suspension_X_Length: 0 m; ZZZ_V Component_02_plane_Integer: 2; ZZZ_V Suspension_min_Length: 0 m; ZZZ_V Detection zone_02_material_Material: RSfr_x_rgb 000 128 255 T80 bleu_gen; ZZZ_V Component_01_description_Text: détecteur; ZZZ_V Suspension_max_Length: 0 m; ZZZ_V Component_01_Y_Length: 0 m; ZZZ_V Detection zone_01_material_Material: RSfr_x_rgb 255 128 128 T80 rouge_gen; ZZZ_V Clearance zone_left_Length: 0 m; ZZZ_V Suspension_length_Length: 0 m; ZZZ_V Suspension_type_FamilyType_Lighting Devices: aucun_gen; RSfr_C_type: capteur de mouvement; RSfr_C_content_version: 1.0.0; RSfr_C_revit_version: 2020; TBQfr_C_licence_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; RSfr_C_code_gtin: -; RSfr_C_type_commentaires: capteur de mouvement; RSfr_C_code_ETIM_url: http://prod.etim-international.com/; RSfr_C_content_date_modifié: 29/09/2023; TBQfr_C_code_produit: -; RSfr_C_content_fournisseur: B.E.G.; RSfr_C_content_créateur: © ThorbiQ; RSfr_C_description: capteur de mouvement; RSfr_C_code_article: -; TBQfr_C_IFC_version: 2x3; RSfr_C_code_classe_de_produit: -; RSfr_C_modèle: capteur de mouvement; TBQfr_C_licence: Creative Commons Attribution NoDerivs (CC-ND); RSfr_C_largeur: 0 m; RSfr_C_hauteur: 0.076 m; TBQfr_C_SOg_LD_2D: aucun; TBQfr_C_accessoires_EE_02: aucun_gen; TBQfr_C_accessoires_EE_05: aucun_gen; RSfr_E_c01_puissance_apparente: 0 VA; RSfr_E_c01_nombre_de_pôles: 1; TBQfr_C_accessoires_EE_03: aucun_gen; RSfr_C_longueur: 0 m; RSfr_E_c01_tension: 230 V; TBQfr_E_c01_oui_non: yes; TBQfr_C_SOg_LD_3D: aucun; TBQfr_C_accessoires_EE_04: aucun_gen; RSfr_C_diamètre: 0.101 m; RSfr_E_c01_sous_indice_de_charge_moteur: no; TBQfr_C_accessoire_01_description: -; RSfr_E_c01_description: -; TBQfr_E_c01_type_de_système: -; TBQ_I BaseKeynote: 62.60.10; TBQ_I Domaine de saisie des données: -; TBQ_I Maître: yes; TBQ_I Esclave: no; TBQ_I Type de sortie: -; Scénario: -; Dimensions du bloc d'alimentation externe: -; Puissance interne W: -; Absorption de courant mA: -; Réglages: -; Surface contrôlée approche tangentielle m² à une hauteur de montage de 2,5 m: -; Hauteur de montage Min. m: -; Hauteur de montage Max. m: -; Hauteur de montage Recommandé m: -; Mesurage du lumière: -; Évaluation de la température: -; Boîtier: -; Longeur de cable cm: -; KNX Nombre de capteurs de luminosité: -; KNX Nombre de capteurs PIR: -; KNX TP 256: -; Canal 01: -; Canal 01 Puissance: -; Canal 01 Lumière d’orientation: -; Canal 01 Nachtlicht: -; Canal 02: -; Canal 02 Puissance: -; Canal 02 Durée de temporisation: -; Canal 02 Lumière d’orientation: -; Canal 02 Seuil d´enchlenchement Lux: -; Détecteur Largeur en mm: -; Détecteur Hauteur en mm: -; Détecteur Profondeur en mm: -; Graphismes - ZZZ_V Position annotation x_Integer: 0; ZZZ_V Position annotation y_Integer: 0; ZZZ_V Displacement annotation y_Length: 0 m; ZZZ_V Displacement annotation x_Length: 0 m; TBQfr_C_zone_libre: no; TBQfr_C_portée_02_description: Frontale; TBQfr_C_portée_01_description: Transversale; TBQfr_C_logo: yes; TBQfr_C_portée_01: no; TBQfr_C_portée_02: no; TBQfr_C_portée_03_description: Activité assise; TBQfr_C_portée_03: no; Construction - ZZZ_V Suspension_height_Length: 0 m; TBQfr_C_alignement: Centre; TBQfr_C_GOg: yes; TBQfr_C_accessoires_EE_01: aucun_gen; TBQfr_C_alignement_index: 0; TBQfr_C_SOg: no; TBQfr_C_hauteur_de_montage: 2.5 m; Electrique - TBQfr_E_facteur_de_puissance: 1; TBQfr_E_c01_facteur_de_puissance: 1; RSfr_E_c01_indice_de_charge: Other
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Family | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0
INTERRUPTEUR VV + PC 2P+T 230V | Type | INTERRUPTEUR VV + PC 2P+T 230V | N0
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR VV + PC 2P+T 230V | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 5554106 | Installations électriques | INTERRUPTEUR VV + PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1547111 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0; Décalage par rapport à l'hôte: 1.0645 m; Élévation par rapport au niveau: 1.0645 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.24; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: yes; SA: no; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Family | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Type | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 5554107 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0 | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.24; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Instance | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 1536502 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Autre - Nom de la famille: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Classe Etim: EC002601 Boîte d'appareillage encastré; Données d'identification - Nom du type: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.142 m; Diamètre: 0.067 m; Hauteur: 0.0728 m; Profondeur: 0.04 m; Electrique - Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg; Fabricant: Legrand
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Family | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Type | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0
