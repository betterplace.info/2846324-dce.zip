Properties of the parts of a building model (IFC4), part 2 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5531453 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5531467 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5531477 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5531541 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD3; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.13; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5531563 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.14; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5567758 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q24; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.38 m; Élévation par rapport au niveau: 2.38 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q24-BD4; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.24; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5567999 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q24; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.38 m; Élévation par rapport au niveau: 2.38 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q24-BD4; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.24; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_BAES GENERIQUE SAILLIE | Family | 604_BAES GENERIQUE SAILLIE | N0_FINI
BAES ↓ | Type | BAES ↓ | N0_FINI
604_BAES GENERIQUE SAILLIE | BAES ↓ | 604_BAES GENERIQUE SAILLIE | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4478428 | Luminaires | BAES ↓ | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4673004 | 2.2 | Luminaires | 0 | Famille : Luminaires : 604_BAES GENERIQUE SAILLIE | 604_BAES GENERIQUE SAILLIE | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: SECURITYLIGHTING; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.3 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000617074 m3; Surface: 0.0642297 m2; Electricité - Charges - Panneau: TD1; Numero de circuit: 24; Electricité - Circuit - Données électriques: 230 V/1-1 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.24; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: SECURITYLIGHTING; ←: no; ↓: yes; →: no; ↑: no; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
6 x 604_BAES GENERIQUE SAILLIE | Instance | 604_BAES GENERIQUE SAILLIE | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4673004 | Luminaires |  |  | Famille : Luminaires : 604_BAES GENERIQUE SAILLIE | Autre - Nom de la famille: 604_BAES GENERIQUE SAILLIE; Données d'identification - Nom du type: BAES ↓; Note d'identification: 600_ELECTRICITE C.FORTS; Contraintes - Elévation par défaut: 2.2 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: SECURITYLIGHTING; Visibilité - ←: no; ↓: yes; →: no; ↑: no
604_BAES GENERIQUE SAILLIE | BAES ↓ | 604_BAES GENERIQUE SAILLIE | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4479415 | Luminaires | BAES ↓ | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4673004 | 2.2 | Luminaires | 0 | Famille : Luminaires : 604_BAES GENERIQUE SAILLIE | 604_BAES GENERIQUE SAILLIE | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: SECURITYLIGHTING; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.27 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000617074 m3; Surface: 0.0642297 m2; Electricité - Charges - Panneau: TD1; Numero de circuit: 24; Electricité - Circuit - Données électriques: 230 V/1-1 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: SECURITYLIGHTING; ←: no; ↓: yes; →: no; ↑: no; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_BAES GENERIQUE SAILLIE | BAES ↓ | 604_BAES GENERIQUE SAILLIE | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4704786 | Luminaires | BAES ↓ | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4673004 | 2.2 | Luminaires | 0 | Famille : Luminaires : 604_BAES GENERIQUE SAILLIE | 604_BAES GENERIQUE SAILLIE | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: SECURITYLIGHTING; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.3 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000617074 m3; Surface: 0.0642297 m2; Electricité - Charges - Panneau: TD1; Numero de circuit: 25; Electricité - Circuit - Données électriques: 230 V/1-1 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: SECURITYLIGHTING; ←: no; ↓: yes; →: no; ↑: no; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_BAES GENERIQUE SAILLIE | BAES ↓ | 604_BAES GENERIQUE SAILLIE | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4705464 | Luminaires | BAES ↓ | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4673004 | 2.2 | Luminaires | 0 | Famille : Luminaires : 604_BAES GENERIQUE SAILLIE | 604_BAES GENERIQUE SAILLIE | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: SECURITYLIGHTING; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.3 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000617074 m3; Surface: 0.0642297 m2; Electricité - Charges - Panneau: TD1; Numero de circuit: 24; Electricité - Circuit - Données électriques: 230 V/1-1 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.25; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: SECURITYLIGHTING; ←: no; ↓: yes; →: no; ↑: no; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_BAES GENERIQUE SAILLIE | BAES ↓ | 604_BAES GENERIQUE SAILLIE | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751123 | Luminaires | BAES ↓ | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4673004 | 2.2 | Luminaires | 0 | Famille : Luminaires : 604_BAES GENERIQUE SAILLIE | 604_BAES GENERIQUE SAILLIE | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: SECURITYLIGHTING; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.1 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000617074 m3; Surface: 0.0642297 m2; Electricité - Charges - Panneau: TD1; Numero de circuit: 24; Electricité - Circuit - Données électriques: 230 V/1-1 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: SECURITYLIGHTING; ←: no; ↓: yes; →: no; ↑: no; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_BAES GENERIQUE SAILLIE | BAES ↓ | 604_BAES GENERIQUE SAILLIE | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751146 | Luminaires | BAES ↓ | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4673004 | 2.2 | Luminaires | 0 | Famille : Luminaires : 604_BAES GENERIQUE SAILLIE | 604_BAES GENERIQUE SAILLIE | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: SECURITYLIGHTING; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.2 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000617074 m3; Surface: 0.0642297 m2; Electricité - Charges - Panneau: TD1; Numero de circuit: 24; Electricité - Circuit - Données électriques: 230 V/1-1 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: SECURITYLIGHTING; ←: no; ↓: yes; →: no; ↑: no; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_DOWNLIGHT 200MM | Family | 604_DOWNLIGHT 200MM | N0_FINI
18W | Type | 18W | N0_FINI
604_DOWNLIGHT 200MM | 18W | 604_DOWNLIGHT 200MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4484339 | Luminaires | 18W | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4668350 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_DOWNLIGHT 200MM | 604_DOWNLIGHT 200MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.47 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.000644923 m3; Surface: 0.062157 m2; Electricité - Charges - Panneau: TD1-Q23-BD6; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-18 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.17; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
4 x 604_DOWNLIGHT 200MM | Instance | 604_DOWNLIGHT 200MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4668350 | Luminaires |  |  | Famille : Luminaires : 604_DOWNLIGHT 200MM | Autre - Nom de la famille: 604_DOWNLIGHT 200MM; Données d'identification - Nom du type: 18W; Note d'identification: 600_ELECTRICITE C.FORTS; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0
604_DOWNLIGHT 200MM | 18W | 604_DOWNLIGHT 200MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4485545 | Luminaires | 18W | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4668350 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_DOWNLIGHT 200MM | 604_DOWNLIGHT 200MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.47 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.000644923 m3; Surface: 0.062157 m2; Electricité - Charges - Panneau: TD1-Q23-BD7; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-18 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.16; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_DOWNLIGHT 200MM | 18W | 604_DOWNLIGHT 200MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4485837 | Luminaires | 18W | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4668350 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_DOWNLIGHT 200MM | 604_DOWNLIGHT 200MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.47 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.000644923 m3; Surface: 0.062157 m2; Electricité - Charges - Panneau: TD1-Q23-BD8; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-18 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.15; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_DOWNLIGHT 200MM | 18W | 604_DOWNLIGHT 200MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4485847 | Luminaires | 18W | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4668350 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_DOWNLIGHT 200MM | 604_DOWNLIGHT 200MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.47 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.000644923 m3; Surface: 0.062157 m2; Electricité - Charges - Panneau: TD1-Q23-BD8; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-18 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.15; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Electricité - Eclairage - Calculer le coefficient d'utilisation: no
604_MIMIK_30_CPT3 | Family | 604_MIMIK_30_CPT3 | N0_FINI
CP/T3 30W 730 WH-87 (303848) | Type | CP/T3 30W 730 WH-87 (303848) | N0_FINI
604_MIMIK_30_CPT3 | CP/T3 30W 730 WH-87 (303848) | 604_MIMIK_30_CPT3 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5656888 | Luminaires | CP/T3 30W 730 WH-87 (303848) | 0 | 2021_015 | yes | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5656824 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_MIMIK_30_CPT3 | 604_MIMIK_30_CPT3 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q26; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.3 m; Élévation par rapport au niveau: 2.25 m; Niveau de nomenclature: N0_FINI; Plan de construction: <non associé>; OrientationAngle: 0 deg; DefaultOrientation: yes; OrientationHeight: -0.0625 m; Cotes - Volume: 0.00145773 m3; Surface: 0.0859392 m2; Electricité - Charges - Panneau: TD1-Q26-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-30 VA; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Lighting; Numéro OmniClass: 23.80.70.00; Fabricant: Performance iN Lighting; Image du type: MIMIK_30_CP-T3.jpg; Modèle: MIMIK 30 CP/T3 30W 730 WH-87; URL: http://www.performanceinlighting.com/qr/products/prod-303848; Puissance apparente: 0 VA; Lampe: LED; ENEC: Yes; IK_Rating: IK06; IP_Rating: IP65; CRI: 70; MacAdam: 3; ColorDescription: PIL_White_Textured; InsulationClass: I; LightsourceFlux: 4160 lm; LuminaireFlux: 2558 lm; OpticType: CP/T3; OpticDescription: CYCLE/PEDESTRIAN TYPE III; LumenMaintenance: L80B10@60000h; EtimGroup: EG000027; EtimClass: EC002892; PilApplication: ARCHITECTURAL; PilType: WALL SURFACE; PilCode: 303848; LuminaireWattage: 30W; EmittingSurface: PIL_Light source_3000K; Wattage: 30 W; LightSource: 303809_MIMIK_30; NetWeight: 1.99 kg; ColorTemperature: 3000; RatedCCT: 3000 K; InputVoltageAC: 198/264; InputVoltageDC: 176/280; SupplyVoltage: 230 V; OverallDiameter: 0 m; OverallWidth: 0.064 m; OverallHeight: 0.125 m; OverallLength: 0.3 m; Height: 0.125 m; Electricité - Eclairage - Calculer le coefficient d'utilisation: no; Graphismes - IconOffset: 0 m
2 x 604_MIMIK_30_CPT3 | Instance | 604_MIMIK_30_CPT3 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5656824 | Luminaires |  |  | Famille : Luminaires : 604_MIMIK_30_CPT3 | Autre - Nom de la famille: 604_MIMIK_30_CPT3; Données d'identification - Nom du type: CP/T3 30W 730 WH-87 (303848); Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Lighting; Numéro OmniClass: 23.80.70.00; Image du type: MIMIK_30_CP-T3.jpg; Modèle: MIMIK 30 CP/T3 30W 730 WH-87; Fabricant: Performance iN Lighting; URL: http://www.performanceinlighting.com/qr/products/prod-303848; EtimGroup: EG000027; EtimClass: EC002892; PilApplication: ARCHITECTURAL; PilType: WALL SURFACE; PilCode: 303848; Contraintes - Elévation par défaut: 1.2192 m; Height: 0.125 m; Paramètres IFC - Exporter le type au format IFC: 0; Electricité - Charges - Puissance apparente: 0 VA; Electrique - Lampe: LED; InsulationClass: I; LuminaireWattage: 30W; Wattage: 30 W; InputVoltageAC: 198/264; InputVoltageDC: 176/280; SupplyVoltage: 230 V; Données - ENEC: Yes; IK_Rating: IK06; IP_Rating: IP65; NetWeight: 1.99 kg; Photométriques - CRI: 70; MacAdam: 3; LightsourceFlux: 4160 lm; LuminaireFlux: 2558 lm; OpticType: CP/T3; OpticDescription: CYCLE/PEDESTRIAN TYPE III; LumenMaintenance: L80B10@60000h; LightSource: 303809_MIMIK_30; ColorTemperature: 3000; RatedCCT: 3000 K; Matériaux et finitions - ColorDescription: PIL_White_Textured; EmittingSurface: PIL_Light source_3000K; Cotes - OverallDiameter: 0 m; OverallWidth: 0.064 m; OverallHeight: 0.125 m; OverallLength: 0.3 m
604_MIMIK_30_CPT3 | CP/T3 30W 730 WH-87 (303848) | 604_MIMIK_30_CPT3 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5656975 | Luminaires | CP/T3 30W 730 WH-87 (303848) | 0 | 2021_015 | yes | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5656824 | 1.2192 | Luminaires | 0 | Famille : Luminaires : 604_MIMIK_30_CPT3 | 604_MIMIK_30_CPT3 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q26; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.3 m; Élévation par rapport au niveau: 2.25 m; Niveau de nomenclature: N0_FINI; Plan de construction: <non associé>; OrientationAngle: 0 deg; DefaultOrientation: yes; OrientationHeight: -0.0625 m; Cotes - Volume: 0.00145773 m3; Surface: 0.0859392 m2; Electricité - Charges - Panneau: TD1-Q26-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-30 VA; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Lighting; Numéro OmniClass: 23.80.70.00; Fabricant: Performance iN Lighting; Image du type: MIMIK_30_CP-T3.jpg; Modèle: MIMIK 30 CP/T3 30W 730 WH-87; URL: http://www.performanceinlighting.com/qr/products/prod-303848; Puissance apparente: 0 VA; Lampe: LED; ENEC: Yes; IK_Rating: IK06; IP_Rating: IP65; CRI: 70; MacAdam: 3; ColorDescription: PIL_White_Textured; InsulationClass: I; LightsourceFlux: 4160 lm; LuminaireFlux: 2558 lm; OpticType: CP/T3; OpticDescription: CYCLE/PEDESTRIAN TYPE III; LumenMaintenance: L80B10@60000h; EtimGroup: EG000027; EtimClass: EC002892; PilApplication: ARCHITECTURAL; PilType: WALL SURFACE; PilCode: 303848; LuminaireWattage: 30W; EmittingSurface: PIL_Light source_3000K; Wattage: 30 W; LightSource: 303809_MIMIK_30; NetWeight: 1.99 kg; ColorTemperature: 3000; RatedCCT: 3000 K; InputVoltageAC: 198/264; InputVoltageDC: 176/280; SupplyVoltage: 230 V; OverallDiameter: 0 m; OverallWidth: 0.064 m; OverallHeight: 0.125 m; OverallLength: 0.3 m; Height: 0.125 m; Electricité - Eclairage - Calculer le coefficient d'utilisation: no; Graphismes - IconOffset: 0 m
604_HUBLOT_LEGRAND_300MM_1000LM | Family | 604_HUBLOT_LEGRAND_300MM_1000LM | N0_FINI
Détection ANTHRACITE | Type | Détection ANTHRACITE | N0_FINI
604_HUBLOT_LEGRAND_300MM_1000LM | Détection ANTHRACITE | 604_HUBLOT_LEGRAND_300MM_1000LM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6915546 | Luminaires | Détection ANTHRACITE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6913912 | 2.5 | Luminaires | 0 | Famille : Luminaires : 604_HUBLOT_LEGRAND_300MM_1000LM | 604_HUBLOT_LEGRAND_300MM_1000LM | Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q36; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 0.8 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.00853167 m3; Surface: 0.391016 m2; Electricité - Charges - Panneau: TD1-Q36-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Type de Revit - Définition de la source d'éclairage (famille): Cercle+Distribution photométrique; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 12 lx; Intensité lumineuse: 110 cd; Efficacité: 149 lm/W; Puissance: 9 W; Fichier de distribution photométrique: SL532100.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: 0 deg; Flux lumineux: 1380 lm; Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: LEGRAND; Modèle: SL-532141; URL: http://www.legrandoc.com/SL532141; Largeur: 0.3 m; Description: CHARTRES ESSENTIEL 1000LM 4000K STANDARD DETECTION HF ANTHRACITE; Longueur: 0.3 m; Emettre à partir du diamètre du cercle: 0.2 m; Emettre la visibilité des formes dans le rendu: no; Condition Générale d'Utilisation: https://export.legrand.com/CGU-objets-BIM; Classe de protection: II; Douille: Sans; Type de tension: CA; Avec détecteur de mouvement: yes; Appareillage: Appareil à LED commandé en courant; Indice de rendu des couleurs CRI: 80-89; Avec détecteur crépusculaire: yes; Matériau du boîtier/corps: Plastique; Source lumineuse: Led non interchangeable; Répartition lumineuse: Symétrique; Indice de protection (IP): IP55; Puissance de la lampe en Multiwatt: Autre; Angle du faisceau: Faisceau libre; Type de variation: Non régulable; Courant nominal mA MAX: 49; Température de couleur K MIN: 4000; Température de couleur K MAX: 4000; Puissance du système W: 10; Flux lumineux utile lm: 1000; Couleur du boîtier/corps: LEGRAND - Anthracite; Courant nominal mA MIN: 39; Indice de protection contre les chocs (IK): IK10; Tension nominale (Un) V MIN: 207; Tension nominale (Un) V MAX: 253; Adapté à une suspension: no; Adapté à un montage en applique: yes; Adapté à un montage encastré: no; Adapté à un montage en saillie: yes; Adapté à un montage au plafond: yes; Diamètre externe: 0.3 m; Hauteur/profondeur: 0.07 m; Diamètre d'encastrement: 0 m; Longueur d'encastrement: 0 m; Largeur d'encastrement: 0.3 m; Hauteur/profondeur d'encastrement: 0 m; Standard Formes 1-3-6: yes; Zone de détection: Détection à 2,5m haut Plafond: Ø6m maxi Mur: Ellipse 16*17m; Graphismes - Afficher la zone de détection-pose murale: no; Afficher la zone de détection-pose plafond: no; Afficher l'étiquette de zone: no; Visibilité - Zone plafond formes 1à7: no; Zone murale formes 1à7: no
604_HUBLOT_LEGRAND_300MM_1000LM | Instance | 604_HUBLOT_LEGRAND_300MM_1000LM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6913912 | Luminaires |  |  | Famille : Luminaires : 604_HUBLOT_LEGRAND_300MM_1000LM | Autre - Nom de la famille: 604_HUBLOT_LEGRAND_300MM_1000LM; Standard Formes 1-3-6: yes; Données d'identification - Nom du type: Détection ANTHRACITE; Note d'identification: 600_ELECTRICITE C.FORTS; Modèle: SL-532141; Fabricant: LEGRAND; URL: http://www.legrandoc.com/SL532141; Description: CHARTRES ESSENTIEL 1000LM 4000K STANDARD DETECTION HF ANTHRACITE; Condition Générale d'Utilisation: https://export.legrand.com/CGU-objets-BIM; Contraintes - Elévation par défaut: 2.5 m; Photométriques - Définition de la source d'éclairage (famille): Cercle+Distribution photométrique; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 3200 K; Eclairement: 12 lx; Intensité lumineuse: 110 cd; Efficacité: 149 lm/W; Puissance: 9 W; Fichier de distribution photométrique: SL532100.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: 0 deg; Flux lumineux: 1380 lm; Emettre à partir du diamètre du cercle: 0.2 m; Emettre la visibilité des formes dans le rendu: no; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Longueur: 0.3 m; Largeur: 0.3 m; Diamètre externe: 0.3 m; Hauteur/profondeur: 0.07 m; Diamètre d'encastrement: 0 m; Longueur d'encastrement: 0 m; Largeur d'encastrement: 0.3 m; Hauteur/profondeur d'encastrement: 0 m; Electrique - Classe de protection: II; Type de tension: CA; Puissance de la lampe en Multiwatt: Autre; Courant nominal mA MAX: 49; Puissance du système W: 10; Flux lumineux utile lm: 1000; Courant nominal mA MIN: 39; Tension nominale (Un) V MIN: 207; Tension nominale (Un) V MAX: 253; Données - Douille: Sans; Avec détecteur de mouvement: yes; Appareillage: Appareil à LED commandé en courant; Indice de rendu des couleurs CRI: 80-89; Avec détecteur crépusculaire: yes; Source lumineuse: Led non interchangeable; Répartition lumineuse: Symétrique; Indice de protection (IP): IP55; Angle du faisceau: Faisceau libre; Type de variation: Non régulable; Température de couleur K MIN: 4000; Température de couleur K MAX: 4000; Indice de protection contre les chocs (IK): IK10; Adapté à une suspension: no; Adapté à un montage en applique: yes; Adapté à un montage encastré: no; Adapté à un montage en saillie: yes; Adapté à un montage au plafond: yes; Matériaux et finitions - Matériau du boîtier/corps: Plastique; Couleur du boîtier/corps: LEGRAND - Anthracite; Texte - Zone de détection: Détection à 2,5m haut Plafond: Ø6m maxi Mur: Ellipse 16*17m
Tableaux/Baies | Category | Tableaux/Baies | N0_FINI
602_CHASSIS 400V | Family | 602_CHASSIS 400V | N0_FINI
2000 x 1800 x 400 | Type | 2000 x 1800 x 400 | N0_FINI
602_CHASSIS 400V | 2000 x 1800 x 400 | 602_CHASSIS 400V | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4687206 | Tableaux/Baies | 2000 x 1800 x 400 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4684443 | 0 | Tableaux/Baies | 0 | Famille : Tableaux/Baies : 602_CHASSIS 400V | 602_CHASSIS 400V | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: DISTRIBUTIONBOARD; Exporter au format IFC sous: IfcElectricDistributionBoard; Données d'identification - GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0 m; Élévation par rapport au niveau: 0 m; Cotes - Volume: 8.28 m3; Surface: 19.54 m2; Electricité - Circuit - Données électriques: 400 V/3-0 VA; Boîtes de raccordement: yes; Option de numérotation de circuit: 1; Nombre de fils: 4; Nombre de phases: 3; Cosses d'artère secondaire: yes; Intensité nominale MCB: 250 A; Attribution d'un nom de circuit: Standard; Système de distribution: 400V AC; ELE_NOMBRE CIRCUITS: 26; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.22; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Distribution Boards and Control Panels; Numéro OmniClass: 23.80.30.11.17; Largeur: 1.8 m; Profondeur: 0.4 m; Arase haute de pose: 2 m; Hauteur: 2 m; Zone de maintenance: yes; Autre - PNST ✓: no; PNST ✗: yes; Electricité - Charges - Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 50 A; Courant du circuit de dérivation Phase B: 44 A; Courant du circuit de dérivation Phase A: 52 A; Puissance apparente du circuit de dérivation - Phase C: 11329 VA; Puissance apparente du circuit de dérivation - Phase B: 10050 VA; Puissance apparente du circuit de dérivation - Phase A: 11821 VA; Courant de Phase C: 50 A; Courant de Phase B: 44 A; Courant de Phase A: 52 A; Intensité requise estimée totale: 48 A; Intensité installée totale: 48 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 33200 VA; Puissance apparente installée totale: 33200 VA; Puissance apparente - Phase C: 11329 VA; Puissance apparente - Phase B: 10050 VA; Puissance apparente - Phase A: 11821 VA; Puissance apparente requise Autre: 12900 VA; Puissance apparente connectée Autre: 12900 VA; Autre - Intensité utilisée estimée: 19 A; Autre - Intensité installée: 19 A; Autre - Coefficient d'utilisation: 100.00%; Puissance apparente requise Eclairage: 0 VA; Puissance apparente connectée Eclairage: 0 VA; Eclairage - Intensité utilisée estimée: 0 A; Eclairage - Intensité installée: 0 A; Other Estimated Demand: 1300 VA; Other Connected: 1300 VA; Other Estimated Demand Current: 2 A; Other Connected Current: 2 A; Other Demand Factor: 100.00%; PC 2P+T 230V - Puissance apparente installée: 19000 VA; PC 2P+T 230V - Puissance apparente requise: 19000 VA; PC 2P+T 230V - Intensité installée: 27 A; PC 2P+T 230V - Intensité requise estimée: 27 A; PC 2P+T 230V - Coefficient d'utilisation: 100.00%; Général - Emplacement: TGBT DC-N0-014; Montage: Au sol; Nom du panneau: TD1; ELE_DIMENSION OUVRAGE: 2000 x 1800 x 400mm; Electrotechnique - ELE_TENSION: 400 V; ELE_RDN: TNC-S; ELE_THD: 25%; ELE_IK2: 12.345 kA; ELE_IK1: 12.345 kA; ELE_IK3: 12.345 kA; ELE_PROTECTION AMONT: INS 250A 4P; Visibilité - PORTE ARMOIRE: no
602_CHASSIS 400V | Instance | 602_CHASSIS 400V | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6411966 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_CHASSIS 400V | Autre - Nom de la famille: 602_CHASSIS 400V; Largeur: 1.8 m; Profondeur: 0.4 m; Arase haute de pose: 2 m; Hauteur: 2 m; Données d'identification - Nom du type: 2000 x 1800 x 400; Titre OmniClass: Distribution Boards and Control Panels; Numéro OmniClass: 23.80.30.11.17; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Visibilité - Zone de maintenance: yes
602_BOITE DE DERIVATION | Family | 602_BOITE DE DERIVATION | N0_FINI
105X105X50 GENERIQUE | Type | 105X105X50 GENERIQUE | N0_FINI
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5420953 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q1; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.6 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.0410162 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 1; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 10 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 2280 VA; Courant de Phase C: 0 A; Courant de Phase B: 0 A; Courant de Phase A: 10 A; Intensité requise estimée totale: 10 A; Intensité installée totale: 10 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 2280 VA; Puissance apparente installée totale: 2280 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 2280 VA; PC 2P+T 230V - Puissance apparente installée: 2280 VA; PC 2P+T 230V - Puissance apparente requise: 2280 VA; PC 2P+T 230V - Intensité installée: 10 A; PC 2P+T 230V - Intensité requise estimée: 10 A; PC 2P+T 230V - Coefficient d'utilisation: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.24; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Emplacement: Pièce DC-N0-016; Nom du panneau: TD1-Q1-BD1; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: PC 230N; Texte - TEXTE 3D: TD1-Q1-BD1
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158250 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5422244 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q2; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.6 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.0410439 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 2; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 10 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 2280 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 0 A; Courant de Phase B: 10 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 10 A; Intensité installée totale: 10 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 2280 VA; Puissance apparente installée totale: 2280 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 2280 VA; Puissance apparente - Phase A: 0 VA; PC 2P+T 230V - Puissance apparente installée: 2280 VA; PC 2P+T 230V - Puissance apparente requise: 2280 VA; PC 2P+T 230V - Intensité installée: 10 A; PC 2P+T 230V - Intensité requise estimée: 10 A; PC 2P+T 230V - Coefficient d'utilisation: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.24; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Emplacement: Pièce DC-N0-016; Nom du panneau: TD1-Q2-BD1; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: PC 230N; Texte - TEXTE 3D: TD1-Q2-BD1
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158253 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5425658 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q4; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.6 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.0410421 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 4; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 0 A; Courant de Phase B: 0 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 0 A; Intensité installée totale: 0 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 0 VA; Puissance apparente installée totale: 0 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 0 VA; Puissance apparente requise Autre: 0 VA; Puissance apparente connectée Autre: 0 VA; Autre - Intensité utilisée estimée: 0 A; Autre - Intensité installée: 0 A; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.24; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Emplacement: Pièce DC-N0-016; Nom du panneau: TD1-Q4-BD1; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: PC 230N; Texte - TEXTE 3D: TD1-Q4-BD1
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158259 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
