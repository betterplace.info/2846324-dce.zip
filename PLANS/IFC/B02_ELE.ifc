Properties of the parts of a building model (IFC4), part 12 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5554003 | Installations électriques | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 715042 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q24; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000955133 m3; Electricité - Charges - Panneau: TD1-Q24-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.036 m; Hauteur: 0.045 m; Classe Etim: EC001590 Appareillage domestique; Réf legrand: LG-077011L; EAN: 3414971575165; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077011L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 31; IK: 04; Courant nominal: 10 A; Tension nominale: 250 V; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_vide | Family | Legrand_Mosaic_vide | N0_FINI
Legrand_Mosaic_vide | Type | Legrand_Mosaic_vide | N0_FINI
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750554 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750556 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750575 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750577 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750674 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750676 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750718 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750720 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750765 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750767 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750811 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750813 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750854 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750856 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751014 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751016 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751071 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751073 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798775 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798777 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798845 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798847 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799288 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799290 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799393 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799395 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799818 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799820 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799898 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799900 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802019 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802021 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802073 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802075 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4804976 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4804978 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805051 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805053 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805552 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805554 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805885 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805887 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4816920 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4817321 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4818076 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4818786 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821132 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821750 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4821838 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822446 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822566 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4822992 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840504 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840506 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840552 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840554 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840570 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840572 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840598 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840600 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840616 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840618 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840634 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840636 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5416222 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5416224 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5525171 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5525173 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5530039 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5532026 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5554004 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5554006 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755785 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755787 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755789 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755791 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755793 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755795 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755797 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755799 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755801 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755803 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755805 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755807 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755809 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755811 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755813 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755815 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755817 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755819 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755821 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755823 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755825 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755827 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755829 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755831 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755833 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755835 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755837 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755839 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755841 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755843 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755845 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755847 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755849 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755851 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755853 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755855 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
Legrand_Mosaic_vide | Legrand_Mosaic_vide | Legrand_Mosaic_vide | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755857 | Installations électriques | Legrand_Mosaic_vide | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676772 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_vide | Legrand_Mosaic_vide | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no
