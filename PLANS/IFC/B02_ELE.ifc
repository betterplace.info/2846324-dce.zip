Properties of the parts of a building model (IFC4), part 20 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755850 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q29; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q29-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755860 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q29; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q29-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755866 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q28; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q28-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755876 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q28; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q28-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755882 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q28; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q28-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755892 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q28; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q28-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755898 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q28; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q28-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755908 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q28; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q28-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755914 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q32; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q32-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755924 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q32; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q32-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755930 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q32; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q32-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755940 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q32; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q32-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755946 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q31; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q31-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755956 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q31; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q31-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755962 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q31; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q31-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755972 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q31; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q31-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6769496 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q30; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q30-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.14; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6782714 | Installations électriques | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 682338 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q30; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.00000614722 m3; Surface: 0.00199119 m2; Electricité - Charges - Panneau: TD1-Q30-BD2; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.13; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.039 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077145L; EAN: 3414971576476; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077145L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 07; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
603_4POSTES_CLS_PUI_LEGRAND | Family | 603_4POSTES_CLS_PUI_LEGRAND | N0_FINI
PC 2P+T 230V_45° X2 + RJ45_FTP-CAT6 X2 | Type | PC 2P+T 230V_45° X2 + RJ45_FTP-CAT6 X2 | N0_FINI
603_4POSTES_CLS_PUI_LEGRAND | PC 2P+T 230V_45° X2 + RJ45_FTP-CAT6 X2 | 603_4POSTES_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4824056 | Installations électriques | PC 2P+T 230V_45° X2 + RJ45_FTP-CAT6 X2 | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 3382184 | 0.3 | Installations électriques | 0 | Famille : Installations électriques : 603_4POSTES_CLS_PUI_LEGRAND | 603_4POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 1.6 m; Niveau de nomenclature: N0_FINI; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_boîte_cloison_sèche_prof_40_3_postes_6_8_mod_horizontal_080043; Plate: Legrand_Mosaic_plaque_8_mod_blanc_078818L; Support frame type: Legrand_Batibox_support_3_postes_6_8_mod_horizontal_080253; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC 2P+T_45°_A_D + RJ45 X3: no; PC 2P+T_45°_A X2 + RJ45 X2: yes; PC 2P+T_45°_A X3 + RJ45: no; PC 2P+T_45°_A_D X4: no; PC 2P+T_45°_A + PC 2P+T_45°_A_D X3: no; PC 2P+T_45°_A X2 + PC 2P+T_45°_A_D X2: no; PC 2P+T_45°_A X3 + PC 2P+T_45°_A_D: no; PC 2P+T_45°_A X4: no; PC 2P+T_45°_A + PC 2P+T_45°_A_D + RJ45 X2: no; PC 2P+T_45°_A + PC 2P+T_45°_A_D X2 + RJ45: no; PC 2P+T_45°_A X2 + PC 2P+T_45°_A_D + RJ45: no; PC 2P+T_45°_A_D X2 + RJ45 X2: no; PC 2P+T_45°_A_D X3 + RJ45: no; PC 2P+T_45°_A + RJ45 X3: no; Visibilité - Interconnexions 3 PC + 1 RJ: no
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Family | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Type | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840503 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; GEM_ELE_CFA_SS REP: PB1; CLE ID APPAREILS CFA: TRACEUR/IMPRIMANTE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-B1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 25; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: TRACEUR/IMPRIMANTE
31 x Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Instance | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1147599 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Autre - Nom de la famille: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Données d'identification - Nom du type: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Note d'identification: 610_ELECTRICITE C.FAIBLES; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.045 m; Hauteur: 0.045 m; Profondeur: 0.0337 m; Electrique - Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Catégorie: 6
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840551 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; GEM_ELE_CFA_SS REP: PB1; CLE ID APPAREILS CFA: TRACEUR/IMPRIMANTE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-B6; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 30; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: TRACEUR/IMPRIMANTE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840569 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; GEM_ELE_CFA_SS REP: PB1; CLE ID APPAREILS CFA: TRACEUR/IMPRIMANTE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A8; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 8; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: TRACEUR/IMPRIMANTE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840597 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; GEM_ELE_CFA_SS REP: PB1; CLE ID APPAREILS CFA: TRACEUR/IMPRIMANTE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A13; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 13; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: TRACEUR/IMPRIMANTE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Instance | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5769171 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Autre - Nom de la famille: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Données d'identification - Nom du type: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.045 m; Hauteur: 0.045 m; Profondeur: 0.0337 m; Electrique - Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Catégorie: 6
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840615 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; GEM_ELE_CFA_SS REP: PB1; CLE ID APPAREILS CFA: TRACEUR/IMPRIMANTE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A3; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 3; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: TRACEUR/IMPRIMANTE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840633 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; GEM_ELE_CFA_SS REP: PB1; CLE ID APPAREILS CFA: TRACEUR/IMPRIMANTE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A20; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 20; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: TRACEUR/IMPRIMANTE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755788 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A14; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 14; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755798 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A15; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 15; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755804 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A16; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 16; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755814 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A17; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 17; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755820 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A23; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 23; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755830 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A24; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 34; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
