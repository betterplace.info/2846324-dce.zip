Properties of the parts of a building model (IFC4), part 17 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755880 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q12; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q12-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755886 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q13; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q13-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755888 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q13; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q13-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755890 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q13; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q13-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755896 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q14; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q14-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755902 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q15; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q15-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755904 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q15; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q15-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755906 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q15; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q15-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755912 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q3; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q3-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755918 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q6; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q6-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755920 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q6; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q6-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755922 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q6; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q6-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755928 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q4; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q4-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755934 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q5; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q5-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755936 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q5; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q5-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755938 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q5; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q5-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755944 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q7; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q7-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755950 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q4; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q4-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755952 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q4; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q4-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755954 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q4; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q4-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755960 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q8; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q8-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755966 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q3; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q3-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755968 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q3; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q3-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755970 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q3; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q3-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6769490 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q9; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q9-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.14; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6769492 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q9; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q9-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.14; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6769494 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q9; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q9-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.14; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6782708 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q9; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q9-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.13; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6782710 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q9; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q9-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.13; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6782712 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q9; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q9-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.13; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
603_1POSTE_CLS_PUI_LEGRAND | Family | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI
PC 2P+T 230V_45° | Type | PC 2P+T 230V_45° | N0_FINI
603_1POSTE_CLS_PUI_LEGRAND | PC 2P+T 230V_45° | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4816916 | Installations électriques | PC 2P+T 230V_45° | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 916677 | 0.3 | Installations électriques | 0 | Famille : Installations électriques : 603_1POSTE_CLS_PUI_LEGRAND | 603_1POSTE_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Plate: Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L; Support frame type: Legrand_Batibox_support_1_poste_2_mod_080251; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_vide; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC 2P+T_45°_A_D_V: no; PC 2P+T_45°_A_D: no; PC_2P+T_45°_V: no; PC 2P+T_A: no; PC 2P+T_45°_A: yes
603_1POSTE_CLS_PUI_LEGRAND | PC 2P+T 230V_45° | 603_1POSTE_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4817317 | Installations électriques | PC 2P+T 230V_45° | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 916677 | 0.3 | Installations électriques | 0 | Famille : Installations électriques : 603_1POSTE_CLS_PUI_LEGRAND | 603_1POSTE_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_1_poste_2_mod_080041; Plate: Legrand_Mosaic_plaque_2_mod_blanc_antimicrobien_078722L; Support frame type: Legrand_Batibox_support_1_poste_2_mod_080251; Module 1: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_vide; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; PC 2P+T_45°_A_D_V: no; PC 2P+T_45°_A_D: no; PC_2P+T_45°_V: no; PC 2P+T_A: no; PC 2P+T_45°_A: yes
