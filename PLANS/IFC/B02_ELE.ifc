Properties of the parts of a building model (IFC4), part 10 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR SA + PC 2P+T 230V | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5525166 | Installations électriques | INTERRUPTEUR SA + PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1546975 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Élévation par rapport au niveau: 1.1 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: yes; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no
PC 2P+T 230V + RJ45_FTP CAT-6 | Type | PC 2P+T 230V + RJ45_FTP CAT-6 | N0_FINI
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | PC 2P+T 230V + RJ45_FTP CAT-6 | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840499 | Installations électriques | PC 2P+T 230V + RJ45_FTP CAT-6 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4778033 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: no; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: yes
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | PC 2P+T 230V + RJ45_FTP CAT-6 | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840547 | Installations électriques | PC 2P+T 230V + RJ45_FTP CAT-6 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4778033 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: no; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: yes
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | PC 2P+T 230V + RJ45_FTP CAT-6 | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840565 | Installations électriques | PC 2P+T 230V + RJ45_FTP CAT-6 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4778033 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: no; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: yes
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | PC 2P+T 230V + RJ45_FTP CAT-6 | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840593 | Installations électriques | PC 2P+T 230V + RJ45_FTP CAT-6 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4778033 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: no; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: yes
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | PC 2P+T 230V + RJ45_FTP CAT-6 | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840611 | Installations électriques | PC 2P+T 230V + RJ45_FTP CAT-6 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4778033 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: no; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: yes
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | PC 2P+T 230V + RJ45_FTP CAT-6 | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840629 | Installations électriques | PC 2P+T 230V + RJ45_FTP CAT-6 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4778033 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: no; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: yes
INTERRUPTEUR VV + PC 2P+T 230V | Type | INTERRUPTEUR VV + PC 2P+T 230V | N0_FINI
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR VV + PC 2P+T 230V | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5553999 | Installations électriques | INTERRUPTEUR VV + PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1547111 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Élévation par rapport au niveau: 1.1 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: yes; SA: no; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Family | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Type | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750550 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
17 x Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Instance | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1536502 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Autre - Nom de la famille: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Classe Etim: EC002601 Boîte d'appareillage encastré; Données d'identification - Nom du type: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.142 m; Diamètre: 0.067 m; Hauteur: 0.0728 m; Profondeur: 0.04 m; Electrique - Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg; Fabricant: Legrand
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750571 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750670 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750714 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750761 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.13; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750807 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.14; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750850 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.22; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751010 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751067 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840500 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840548 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840566 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840594 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Instance | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802747 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Autre - Nom de la famille: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Classe Etim: EC002601 Boîte d'appareillage encastré; Données d'identification - Nom du type: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.142 m; Diamètre: 0.067 m; Hauteur: 0.0728 m; Profondeur: 0.04 m; Electrique - Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg; Fabricant: Legrand
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840612 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840630 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5416218 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5525167 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5554000 | Installations électriques | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536502 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000235014 m3; Surface: 0.0240472 m2; Type de Revit - Fabricant: Legrand; Largeur: 0.142 m; Profondeur: 0.04 m; Hauteur: 0.0728 m; Diamètre: 0.067 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080042; EAN: 3245060800420; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080042-LEGRAND-1000.jpg
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Family | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Type | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750551 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
17 x Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Instance | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1536501 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Autre - Nom de la famille: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Classe Etim: EC002948 support pour installation domotique modulaire; Données d'identification - Nom du type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.145 m; Hauteur: 0.077 m; Profondeur: 0.0157 m; Electrique - Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750572 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750671 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750715 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750762 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.13; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750808 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.14; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750851 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.22; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751011 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751068 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840501 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840549 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
