Properties of the parts of a building model (IFC4), part 26 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | <NoLevel> | CurrentWithCentral | NotOwned | boulanger-mathe | 7158439 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
Chemins de câbles | Category | Chemins de câbles | N0
Chemin de câbles avec raccords | Family | Chemin de câbles avec raccords | N0
Chemin de câbles à base pleine | Type | Chemin de câbles à base pleine | N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4500282 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 6.22528 m; Largeur: 100 mm; Hauteur: 50 mm; Taille: 100 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 2; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4500815 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 0.931106 m; Largeur: 100 mm; Hauteur: 50 mm; Taille: 100 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 1; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4503161 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 5.41937 m; Largeur: 100 mm; Hauteur: 50 mm; Taille: 100 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 2; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4697973 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 0.37 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.03 m; Arase inférieure à son extrémité amont: 2.4 m; Elévation de l'axe à son extrémité aval: 2.03 m; Elévation de l'axe à son extrémité amont: 2.4 m; Arase inférieure à son extrémité aval: 2.03 m; Arase supérieure à son extrémité amont: 2.4 m; Elévation du milieu: 2.03 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.4 m; Élévation centrale de départ: 2.03 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4697974 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 0.0115192 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.725 m; Arase inférieure à son extrémité amont: 2.675 m; Elévation de l'axe à son extrémité aval: 2.7 m; Elévation de l'axe à son extrémité amont: 2.7 m; Arase inférieure à son extrémité aval: 2.675 m; Arase supérieure à son extrémité amont: 2.725 m; Elévation du milieu: 2.7 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.7 m; Élévation centrale de départ: 2.7 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698024 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 0.575282 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.725 m; Arase inférieure à son extrémité amont: 2.675 m; Elévation de l'axe à son extrémité aval: 2.7 m; Elévation de l'axe à son extrémité amont: 2.7 m; Arase inférieure à son extrémité aval: 2.675 m; Arase supérieure à son extrémité amont: 2.725 m; Elévation du milieu: 2.7 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.7 m; Élévation centrale de départ: 2.7 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698078 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 0.112943 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.725 m; Arase inférieure à son extrémité amont: 2.675 m; Elévation de l'axe à son extrémité aval: 2.7 m; Elévation de l'axe à son extrémité amont: 2.7 m; Arase inférieure à son extrémité aval: 2.675 m; Arase supérieure à son extrémité amont: 2.725 m; Elévation du milieu: 2.7 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.7 m; Élévation centrale de départ: 2.7 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698320 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 3.75693 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 1; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698328 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 1.37686 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Commentaires: Prevision travaux seconde partie; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698416 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 3.45734 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698705 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 3.7047 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.475 m; Arase inférieure à son extrémité amont: 2.425 m; Elévation de l'axe à son extrémité aval: 2.45 m; Elévation de l'axe à son extrémité amont: 2.45 m; Arase inférieure à son extrémité aval: 2.425 m; Arase supérieure à son extrémité amont: 2.475 m; Elévation du milieu: 2.45 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.45 m; Élévation centrale de départ: 2.45 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698711 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 1.16331 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Commentaires: Prevision travaux seconde partie; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.475 m; Arase inférieure à son extrémité amont: 2.425 m; Elévation de l'axe à son extrémité aval: 2.45 m; Elévation de l'axe à son extrémité amont: 2.45 m; Arase inférieure à son extrémité aval: 2.425 m; Arase supérieure à son extrémité amont: 2.475 m; Elévation du milieu: 2.45 m; Justification verticale: 0; Justification horizontale: 1; Élévation centrale de fin: 2.45 m; Élévation centrale de départ: 2.45 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4699815 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 5.89874 m; Largeur: 100 mm; Hauteur: 50 mm; Taille: 100 mmx50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.475 m; Arase inférieure à son extrémité amont: 2.425 m; Elévation de l'axe à son extrémité aval: 2.45 m; Elévation de l'axe à son extrémité amont: 2.45 m; Arase inférieure à son extrémité aval: 2.425 m; Arase supérieure à son extrémité amont: 2.475 m; Elévation du milieu: 2.45 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.45 m; Élévation centrale de départ: 2.45 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4700004 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 1.54404 m; Largeur: 100 mm; Hauteur: 50 mm; Taille: 100 mmx50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.475 m; Arase inférieure à son extrémité amont: 2.425 m; Elévation de l'axe à son extrémité aval: 2.45 m; Elévation de l'axe à son extrémité amont: 2.45 m; Arase inférieure à son extrémité aval: 2.425 m; Arase supérieure à son extrémité amont: 2.475 m; Elévation du milieu: 2.45 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.45 m; Élévation centrale de départ: 2.45 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4700561 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 5.22913 m; Largeur: 100 mm; Hauteur: 50 mm; Taille: 100 mmx50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.475 m; Arase inférieure à son extrémité amont: 2.425 m; Elévation de l'axe à son extrémité aval: 2.45 m; Elévation de l'axe à son extrémité amont: 2.45 m; Arase inférieure à son extrémité aval: 2.425 m; Arase supérieure à son extrémité amont: 2.475 m; Elévation du milieu: 2.45 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.45 m; Élévation centrale de départ: 2.45 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4700792 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 0.0788548 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.82499 m; Arase inférieure à son extrémité amont: 2.77499 m; Elévation de l'axe à son extrémité aval: 2.79999 m; Elévation de l'axe à son extrémité amont: 2.79999 m; Arase inférieure à son extrémité aval: 2.77499 m; Arase supérieure à son extrémité amont: 2.82499 m; Elévation du milieu: 2.79999 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.79999 m; Élévation centrale de départ: 2.79999 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4700799 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 3.18783 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.475 m; Arase inférieure à son extrémité amont: 2.425 m; Elévation de l'axe à son extrémité aval: 2.45 m; Elévation de l'axe à son extrémité amont: 2.45 m; Arase inférieure à son extrémité aval: 2.425 m; Arase supérieure à son extrémité amont: 2.475 m; Elévation du milieu: 2.45 m; Justification verticale: 0; Justification horizontale: 1; Élévation centrale de fin: 2.45 m; Élévation centrale de départ: 2.45 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4700893 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 2.80141 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.82499 m; Arase inférieure à son extrémité amont: 2.775 m; Elévation de l'axe à son extrémité aval: 2.79999 m; Elévation de l'axe à son extrémité amont: 2.8 m; Arase inférieure à son extrémité aval: 2.77499 m; Arase supérieure à son extrémité amont: 2.825 m; Elévation du milieu: 2.79999 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.8 m; Élévation centrale de départ: 2.79999 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6391357 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 0.106147 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.475 m; Arase inférieure à son extrémité amont: 2.425 m; Elévation de l'axe à son extrémité aval: 2.45 m; Elévation de l'axe à son extrémité amont: 2.45 m; Arase inférieure à son extrémité aval: 2.425 m; Arase supérieure à son extrémité amont: 2.475 m; Elévation du milieu: 2.45 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.45 m; Élévation centrale de départ: 2.45 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6391358 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 0.158563 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.58662 m; Arase inférieure à son extrémité amont: 2.66338 m; Elévation de l'axe à son extrémité aval: 2.56894 m; Elévation de l'axe à son extrémité amont: 2.68106 m; Arase inférieure à son extrémité aval: 2.55126 m; Arase supérieure à son extrémité amont: 2.69874 m; Elévation du milieu: 2.56894 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.68106 m; Élévation centrale de départ: 2.56894 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6391681 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 0.189047 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6391682 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 0.129423 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.58929 m; Arase inférieure à son extrémité amont: 2.61071 m; Elévation de l'axe à son extrémité aval: 2.56764 m; Elévation de l'axe à son extrémité amont: 2.63236 m; Arase inférieure à son extrémité aval: 2.54599 m; Arase supérieure à son extrémité amont: 2.65401 m; Elévation du milieu: 2.56764 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.63236 m; Élévation centrale de départ: 2.56764 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6395854 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 2.25202 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.475 m; Arase inférieure à son extrémité amont: 2.425 m; Elévation de l'axe à son extrémité aval: 2.45 m; Elévation de l'axe à son extrémité amont: 2.45 m; Arase inférieure à son extrémité aval: 2.425 m; Arase supérieure à son extrémité amont: 2.475 m; Elévation du milieu: 2.45 m; Justification verticale: 2; Justification horizontale: 2; Élévation centrale de fin: 2.45 m; Élévation centrale de départ: 2.45 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6395855 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 0.295294 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.475 m; Arase inférieure à son extrémité amont: 2.425 m; Elévation de l'axe à son extrémité aval: 2.45 m; Elévation de l'axe à son extrémité amont: 2.45 m; Arase inférieure à son extrémité aval: 2.425 m; Arase supérieure à son extrémité amont: 2.475 m; Elévation du milieu: 2.45 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.45 m; Élévation centrale de départ: 2.45 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6395856 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 1.88599 m; Largeur: 100 mm; Hauteur: 50 mm; Taille: 100 mmx50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.475 m; Arase inférieure à son extrémité amont: 2.425 m; Elévation de l'axe à son extrémité aval: 2.45 m; Elévation de l'axe à son extrémité amont: 2.45 m; Arase inférieure à son extrémité aval: 2.425 m; Arase supérieure à son extrémité amont: 2.475 m; Elévation du milieu: 2.45 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.45 m; Élévation centrale de départ: 2.45 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6397240 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 1.56927 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 2; Justification horizontale: 1; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6397241 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 0.794239 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6397242 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 1.94078 m; Largeur: 100 mm; Hauteur: 50 mm; Taille: 100 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 2; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6517547 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 0.794695 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.475 m; Arase inférieure à son extrémité amont: 2.425 m; Elévation de l'axe à son extrémité aval: 2.45 m; Elévation de l'axe à son extrémité amont: 2.45 m; Arase inférieure à son extrémité aval: 2.425 m; Arase supérieure à son extrémité amont: 2.475 m; Elévation du milieu: 2.45 m; Justification verticale: 0; Justification horizontale: 1; Élévation centrale de fin: 2.45 m; Élévation centrale de départ: 2.45 m; Niveau de référence: N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6518605 | Chemins de câbles | Chemin de câbles à base pleine | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 411330 |  | Chemins de câbles | 0 | Types de chemins de câbles | Chemin de câbles avec raccords | Paramètres IFC - Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Cotes - Longueur: 0.268546 m; Largeur: 200 mm; Hauteur: 50 mm; Taille: 200 mmx50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Type de Revit - Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0
Raccords de chemins de câbles | Category | Raccords de chemins de câbles | N0
Chemin de câbles - Courbure convexe | Family | Chemin de câbles - Courbure convexe | N0
5 x Standard | Type | Standard | N0
Chemin de câbles - Courbure convexe | Standard | Chemin de câbles - Courbure convexe | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698021 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 518183 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure convexe | Chemin de câbles - Courbure convexe | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.7 m; Cotes - Volume: 0.00503422 m3; Taille: 200 mmx50 mm-200 mmx50 mm; Rayon de courbure: 200 mm; Epaisseur: 3 mm; Longueur de chemin: 75 mm; Angle: 90 deg; l: 200 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 300 mm; Libellé sur le rayon de courbure: 225 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure convexe | Instance | Chemin de câbles - Courbure convexe | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4695745 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure convexe | Autre - Nom de la famille: Chemin de câbles - Courbure convexe; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure convexe | Standard | Chemin de câbles - Courbure convexe | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6391371 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 518183 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure convexe | Chemin de câbles - Courbure convexe | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.79999 m; Cotes - Volume: 0.00326715 m3; Taille: 200 mmx50 mm-200 mmx50 mm; Rayon de courbure: 200 mm; Epaisseur: 3 mm; Longueur de chemin: 75 mm; Angle: 45.0008 deg; l: 200 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 168 mm; Libellé sur le rayon de courbure: 225 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure convexe | Instance | Chemin de câbles - Courbure convexe | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6391363 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure convexe | Autre - Nom de la famille: Chemin de câbles - Courbure convexe; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure convexe | Standard | Chemin de câbles - Courbure convexe | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6391690 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 518183 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure convexe | Chemin de câbles - Courbure convexe | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.7 m; Cotes - Volume: 0.00267808 m3; Taille: 200 mmx50 mm-200 mmx50 mm; Rayon de courbure: 200 mm; Epaisseur: 3 mm; Longueur de chemin: 75 mm; Angle: 30 deg; l: 200 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 135 mm; Libellé sur le rayon de courbure: 225 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure convexe | Instance | Chemin de câbles - Courbure convexe | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6391687 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure convexe | Autre - Nom de la famille: Chemin de câbles - Courbure convexe; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure | Family | Chemin de câbles - Courbure | N0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698034 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 515513 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Chemin de câbles - Courbure | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.7 m; Cotes - Volume: 0.00631236 m3; Taille: 200 mmx50 mm-200 mmx50 mm; Rayon de courbure: 200 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 90 deg; l: 200 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 380 mm; Libellé sur le rayon de courbure: 300 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698035 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698374 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 515513 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Chemin de câbles - Courbure | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Cotes - Volume: 0.00169248 m3; Taille: 200 mmx50 mm-200 mmx50 mm; Rayon de courbure: 200 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 1.76626 deg; l: 200 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 85 mm; Libellé sur le rayon de courbure: 300 mm; Graphismes - Utiliser l'échelle d'annotations: no
2 x Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698375 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4699607 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 515513 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Chemin de câbles - Courbure | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.45 m; Cotes - Volume: 0.00169248 m3; Taille: 200 mmx50 mm-200 mmx50 mm; Rayon de courbure: 200 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 1.76626 deg; l: 200 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 85 mm; Libellé sur le rayon de courbure: 300 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4699690 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 515513 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Chemin de câbles - Courbure | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Cotes - Volume: 0.00197706 m3; Taille: 100 mmx50 mm-100 mmx50 mm; Rayon de courbure: 100 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 89.9212 deg; l: 100 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: yes; GEM_ELE_CFA: no; GEM_ELE_SSI: no; Autre - Courbure ou raccord: 2; Centre à extrémité: 230 mm; Libellé sur le rayon de courbure: 150 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4698532 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4700652 | Raccords de chemins de câbles | Standard | 0 | 2021_015 |  | yes |  | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 515513 | 0 | Raccords de chemins de câbles | 0 | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Chemin de câbles - Courbure | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcCableCarrierFittingType; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.45 m; Cotes - Volume: 0.00197819 m3; Taille: 100 mmx50 mm-100 mmx50 mm; Rayon de courbure: 100 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 90.0076 deg; l: 100 mm; h: 50 mm; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: yes; Autre - Courbure ou raccord: 2; Centre à extrémité: 230 mm; Libellé sur le rayon de courbure: 150 mm; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 4700653 | Raccords de chemins de câbles |  |  | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
