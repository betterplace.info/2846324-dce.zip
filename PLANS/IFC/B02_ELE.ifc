Properties of the parts of a building model (IFC4), part 14 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5530040 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q22; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q22-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5532027 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q22; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q22-BD3; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.23; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5554005 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q22; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q22-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6842046 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 906741 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L | Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q33; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661505 m3; Electricité - Charges - Panneau: TD1-Q33-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-380 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077111L; EAN: 3414971575967; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077111L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
603_10POSTES_CLS_PUI_LEGRAND | Family | 603_10POSTES_CLS_PUI_LEGRAND | N0_FINI
6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | Type | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | N0_FINI
603_10POSTES_CLS_PUI_LEGRAND | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 603_10POSTES_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798770 | Installations électriques | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6728498 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_10POSTES_CLS_PUI_LEGRAND | 603_10POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128; Plate: Legrand_Mosaic_plaque_2x10_mod_blanc_078828L; Support frame type: Legrand_Batibox_support_2X10_mod_080268; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 20: Legrand_Mosaic_vide; Visibilité - Interconnexions: yes
603_10POSTES_CLS_PUI_LEGRAND | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 603_10POSTES_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798840 | Installations électriques | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6728498 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_10POSTES_CLS_PUI_LEGRAND | 603_10POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128; Plate: Legrand_Mosaic_plaque_2x10_mod_blanc_078828L; Support frame type: Legrand_Batibox_support_2X10_mod_080268; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 20: Legrand_Mosaic_vide; Visibilité - Interconnexions: yes
603_10POSTES_CLS_PUI_LEGRAND | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 603_10POSTES_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799283 | Installations électriques | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6728498 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_10POSTES_CLS_PUI_LEGRAND | 603_10POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128; Plate: Legrand_Mosaic_plaque_2x10_mod_blanc_078828L; Support frame type: Legrand_Batibox_support_2X10_mod_080268; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 20: Legrand_Mosaic_vide; Visibilité - Interconnexions: yes
603_10POSTES_CLS_PUI_LEGRAND | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 603_10POSTES_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799388 | Installations électriques | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6728498 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_10POSTES_CLS_PUI_LEGRAND | 603_10POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128; Plate: Legrand_Mosaic_plaque_2x10_mod_blanc_078828L; Support frame type: Legrand_Batibox_support_2X10_mod_080268; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 20: Legrand_Mosaic_vide; Visibilité - Interconnexions: yes
603_10POSTES_CLS_PUI_LEGRAND | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 603_10POSTES_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799813 | Installations électriques | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6728498 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_10POSTES_CLS_PUI_LEGRAND | 603_10POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128; Plate: Legrand_Mosaic_plaque_2x10_mod_blanc_078828L; Support frame type: Legrand_Batibox_support_2X10_mod_080268; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 20: Legrand_Mosaic_vide; Visibilité - Interconnexions: yes
603_10POSTES_CLS_PUI_LEGRAND | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 603_10POSTES_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799893 | Installations électriques | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6728498 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_10POSTES_CLS_PUI_LEGRAND | 603_10POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128; Plate: Legrand_Mosaic_plaque_2x10_mod_blanc_078828L; Support frame type: Legrand_Batibox_support_2X10_mod_080268; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 20: Legrand_Mosaic_vide; Visibilité - Interconnexions: yes
603_10POSTES_CLS_PUI_LEGRAND | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 603_10POSTES_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802014 | Installations électriques | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6728498 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_10POSTES_CLS_PUI_LEGRAND | 603_10POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128; Plate: Legrand_Mosaic_plaque_2x10_mod_blanc_078828L; Support frame type: Legrand_Batibox_support_2X10_mod_080268; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 20: Legrand_Mosaic_vide; Visibilité - Interconnexions: yes
603_10POSTES_CLS_PUI_LEGRAND | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 603_10POSTES_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802068 | Installations électriques | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6728498 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_10POSTES_CLS_PUI_LEGRAND | 603_10POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128; Plate: Legrand_Mosaic_plaque_2x10_mod_blanc_078828L; Support frame type: Legrand_Batibox_support_2X10_mod_080268; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 20: Legrand_Mosaic_vide; Visibilité - Interconnexions: yes
603_10POSTES_CLS_PUI_LEGRAND | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 603_10POSTES_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4804971 | Installations électriques | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6728498 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_10POSTES_CLS_PUI_LEGRAND | 603_10POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128; Plate: Legrand_Mosaic_plaque_2x10_mod_blanc_078828L; Support frame type: Legrand_Batibox_support_2X10_mod_080268; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 20: Legrand_Mosaic_vide; Visibilité - Interconnexions: yes
603_10POSTES_CLS_PUI_LEGRAND | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 603_10POSTES_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805046 | Installations électriques | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6728498 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_10POSTES_CLS_PUI_LEGRAND | 603_10POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128; Plate: Legrand_Mosaic_plaque_2x10_mod_blanc_078828L; Support frame type: Legrand_Batibox_support_2X10_mod_080268; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 20: Legrand_Mosaic_vide; Visibilité - Interconnexions: yes
603_10POSTES_CLS_PUI_LEGRAND | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 603_10POSTES_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805547 | Installations électriques | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6728498 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_10POSTES_CLS_PUI_LEGRAND | 603_10POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128; Plate: Legrand_Mosaic_plaque_2x10_mod_blanc_078828L; Support frame type: Legrand_Batibox_support_2X10_mod_080268; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 20: Legrand_Mosaic_vide; Visibilité - Interconnexions: yes
603_10POSTES_CLS_PUI_LEGRAND | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 603_10POSTES_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805880 | Installations électriques | 6X PC2P+T_45°_A_D + 2X PC2P+T_45°_A + 2X RJ45 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 6728498 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_10POSTES_CLS_PUI_LEGRAND | 603_10POSTES_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 0.3 m; Élévation par rapport au niveau: 0.3 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128; Plate: Legrand_Mosaic_plaque_2x10_mod_blanc_078828L; Support frame type: Legrand_Batibox_support_2X10_mod_080268; Module 1: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_link_prise_2P+T_FB_surface_2_mod_blanc_077145L; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565; Module 20: Legrand_Mosaic_vide; Visibilité - Interconnexions: yes
Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Family | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | N0_FINI
Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Type | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | N0_FINI
Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798771 | Installations électriques | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777333 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000879555 m3; Surface: 0.0892464 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Fabricant: Legrand; Profondeur: 0.05 m; Hauteur: 0.154 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080128; EAN: 3245060801281; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080128-LEGRAND-1000.jpg
12 x Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Instance | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4777333 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Autre - Nom de la famille: Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128; Classe Etim: EC002601 Boîte d'appareillage encastré; Données d'identification - Nom du type: Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Hauteur: 0.154 m; Profondeur: 0.05 m; Electrique - Réf legrand: LG-080128; EAN: 3245060801281; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080128-LEGRAND-1000.jpg; Fabricant: Legrand
Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798841 | Installations électriques | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777333 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000879555 m3; Surface: 0.0892464 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Fabricant: Legrand; Profondeur: 0.05 m; Hauteur: 0.154 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080128; EAN: 3245060801281; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080128-LEGRAND-1000.jpg
Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799284 | Installations électriques | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777333 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000879555 m3; Surface: 0.0892464 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Fabricant: Legrand; Profondeur: 0.05 m; Hauteur: 0.154 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080128; EAN: 3245060801281; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080128-LEGRAND-1000.jpg
Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799389 | Installations électriques | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777333 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000879555 m3; Surface: 0.0892464 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Fabricant: Legrand; Profondeur: 0.05 m; Hauteur: 0.154 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080128; EAN: 3245060801281; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080128-LEGRAND-1000.jpg
Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799814 | Installations électriques | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777333 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000879555 m3; Surface: 0.0892464 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Fabricant: Legrand; Profondeur: 0.05 m; Hauteur: 0.154 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080128; EAN: 3245060801281; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080128-LEGRAND-1000.jpg
Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799894 | Installations électriques | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777333 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000879555 m3; Surface: 0.0892464 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Fabricant: Legrand; Profondeur: 0.05 m; Hauteur: 0.154 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080128; EAN: 3245060801281; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080128-LEGRAND-1000.jpg
Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802015 | Installations électriques | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777333 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000879555 m3; Surface: 0.0892464 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Fabricant: Legrand; Profondeur: 0.05 m; Hauteur: 0.154 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080128; EAN: 3245060801281; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080128-LEGRAND-1000.jpg
Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802069 | Installations électriques | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777333 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000879555 m3; Surface: 0.0892464 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Fabricant: Legrand; Profondeur: 0.05 m; Hauteur: 0.154 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080128; EAN: 3245060801281; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080128-LEGRAND-1000.jpg
Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4804972 | Installations électriques | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777333 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000879555 m3; Surface: 0.0892464 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Fabricant: Legrand; Profondeur: 0.05 m; Hauteur: 0.154 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080128; EAN: 3245060801281; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080128-LEGRAND-1000.jpg
Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805047 | Installations électriques | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777333 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000879555 m3; Surface: 0.0892464 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Fabricant: Legrand; Profondeur: 0.05 m; Hauteur: 0.154 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080128; EAN: 3245060801281; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080128-LEGRAND-1000.jpg
Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805548 | Installations électriques | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777333 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000879555 m3; Surface: 0.0892464 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Fabricant: Legrand; Profondeur: 0.05 m; Hauteur: 0.154 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080128; EAN: 3245060801281; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080128-LEGRAND-1000.jpg
Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805881 | Installations électriques | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777333 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | Legrand_Batibox_multimatériaux_prof_50_2x10_mod_080128 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000879555 m3; Surface: 0.0892464 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Fabricant: Legrand; Profondeur: 0.05 m; Hauteur: 0.154 m; Classe Etim: EC002601 Boîte d'appareillage encastré; Réf legrand: LG-080128; EAN: 3245060801281; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080128-LEGRAND-1000.jpg
Legrand_Batibox_support_2X10_mod_080268 | Family | Legrand_Batibox_support_2X10_mod_080268 | N0_FINI
Legrand_Batibox_support_2X10_mod_080268 | Type | Legrand_Batibox_support_2X10_mod_080268 | N0_FINI
Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798772 | Installations électriques | Legrand_Batibox_support_2X10_mod_080268 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777336 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000084202 m3; Surface: 0.0310263 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Fabricant: Legrand; Largeur: 0.3035 m; Profondeur: 0.0037 m; Hauteur: 0.1515 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080268; EAN: 3245060802684; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080268-LEGRAND-1000.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal et vertical; Fixation: A vis
12 x Legrand_Batibox_support_2X10_mod_080268 | Instance | Legrand_Batibox_support_2X10_mod_080268 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4777336 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Batibox_support_2X10_mod_080268 | Autre - Nom de la famille: Legrand_Batibox_support_2X10_mod_080268; Classe Etim: EC002948 support pour installation domotique modulaire; Données d'identification - Nom du type: Legrand_Batibox_support_2X10_mod_080268; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.3035 m; Hauteur: 0.1515 m; Profondeur: 0.0037 m; Electrique - Réf legrand: LG-080268; EAN: 3245060802684; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080268-LEGRAND-1000.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 10; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798842 | Installations électriques | Legrand_Batibox_support_2X10_mod_080268 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777336 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000084202 m3; Surface: 0.0310263 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Fabricant: Legrand; Largeur: 0.3035 m; Profondeur: 0.0037 m; Hauteur: 0.1515 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080268; EAN: 3245060802684; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080268-LEGRAND-1000.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799285 | Installations électriques | Legrand_Batibox_support_2X10_mod_080268 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777336 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000084202 m3; Surface: 0.0310263 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Fabricant: Legrand; Largeur: 0.3035 m; Profondeur: 0.0037 m; Hauteur: 0.1515 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080268; EAN: 3245060802684; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080268-LEGRAND-1000.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799390 | Installations électriques | Legrand_Batibox_support_2X10_mod_080268 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777336 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000084202 m3; Surface: 0.0310263 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Fabricant: Legrand; Largeur: 0.3035 m; Profondeur: 0.0037 m; Hauteur: 0.1515 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080268; EAN: 3245060802684; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080268-LEGRAND-1000.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799815 | Installations électriques | Legrand_Batibox_support_2X10_mod_080268 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777336 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000084202 m3; Surface: 0.0310263 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Fabricant: Legrand; Largeur: 0.3035 m; Profondeur: 0.0037 m; Hauteur: 0.1515 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080268; EAN: 3245060802684; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080268-LEGRAND-1000.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799895 | Installations électriques | Legrand_Batibox_support_2X10_mod_080268 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777336 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000084202 m3; Surface: 0.0310263 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Fabricant: Legrand; Largeur: 0.3035 m; Profondeur: 0.0037 m; Hauteur: 0.1515 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080268; EAN: 3245060802684; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080268-LEGRAND-1000.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802016 | Installations électriques | Legrand_Batibox_support_2X10_mod_080268 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777336 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000084202 m3; Surface: 0.0310263 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Fabricant: Legrand; Largeur: 0.3035 m; Profondeur: 0.0037 m; Hauteur: 0.1515 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080268; EAN: 3245060802684; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080268-LEGRAND-1000.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal et vertical; Fixation: A vis
