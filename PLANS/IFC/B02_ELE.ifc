Properties of the parts of a building model (IFC4), part 21 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755836 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A21; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 21; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755846 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A22; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 22; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755852 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-B4; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 27; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755862 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-B5; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 28; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755868 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-B2; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 24; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755878 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-B3; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 26; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755884 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-B7; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 29; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755894 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-B8; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 31; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755900 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-B9; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 32; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755910 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-B10; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 33; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755916 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A4; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 4; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755926 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A5; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 5; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755932 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A6; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 6; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755942 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A7; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 7; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755948 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A11; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 11; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755958 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A12; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 12; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755964 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A9; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 9; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6755974 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A10; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 10; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6769498 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A19; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 19; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.14; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6782716 | Installations électriques | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1147599 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Legrand_Mosaic_prise_RJ45_cat_6_FTP_2_mod_blanc_076565 | Paramètres IFC - Type prédéfini d'IFC: NETWORKAPPLIANCE; Exporter au format IFC sous: IfcCommunicationsApplianceType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; CLE ID APPAREILS CFA: POSTE INFORMATIQUE; GEM_ELE_CFA_NOM PRISE RJ: RTD-1-A18; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000518643 m3; Electricité - Charges - Panneau: BAIE RTD; Numero de circuit: 18; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.13; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.0337 m; Hauteur: 0.045 m; Classe Etim: EC001264 Prise de raccordement de communication cuivre; Réf legrand: LG-076565; EAN: 3245060765651; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/076565-LEGRAND-1000.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; RAL: 9003; IP: 20; IK: 03; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50; Texte - GEM_ELE_CFA_APPAREIL: POSTE INFORMATIQUE
Legrand_Mosaic_plaque_2_mod_blanc_078802L | Family | Legrand_Mosaic_plaque_2_mod_blanc_078802L | N0_FINI
Legrand_Mosaic_plaque_2_mod_blanc_078802L | Type | Legrand_Mosaic_plaque_2_mod_blanc_078802L | N0_FINI
Legrand_Mosaic_plaque_2_mod_blanc_078802L | Legrand_Mosaic_plaque_2_mod_blanc_078802L | Legrand_Mosaic_plaque_2_mod_blanc_078802L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5530038 | Installations électriques | Legrand_Mosaic_plaque_2_mod_blanc_078802L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676763 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2_mod_blanc_078802L | Legrand_Mosaic_plaque_2_mod_blanc_078802L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000380515 m3; Surface: 0.00659947 m2; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078802L; EAN: 3414971577756; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078802L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
3 x Legrand_Mosaic_plaque_2_mod_blanc_078802L | Instance | Legrand_Mosaic_plaque_2_mod_blanc_078802L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 676763 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_plaque_2_mod_blanc_078802L | Autre - Nom de la famille: Legrand_Mosaic_plaque_2_mod_blanc_078802L; Classe Etim: EC000007 Cadre de finition; Données d'identification - Nom du type: Legrand_Mosaic_plaque_2_mod_blanc_078802L; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.082 m; Hauteur: 0.082 m; Profondeur: 0.009 m; Electrique - Réf legrand: LG-078802L; EAN: 3414971577756; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078802L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2_mod_blanc_078802L | Legrand_Mosaic_plaque_2_mod_blanc_078802L | Legrand_Mosaic_plaque_2_mod_blanc_078802L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5532025 | Installations électriques | Legrand_Mosaic_plaque_2_mod_blanc_078802L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676763 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2_mod_blanc_078802L | Legrand_Mosaic_plaque_2_mod_blanc_078802L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000380515 m3; Surface: 0.00659947 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.23; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078802L; EAN: 3414971577756; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078802L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2_mod_blanc_078802L | Legrand_Mosaic_plaque_2_mod_blanc_078802L | Legrand_Mosaic_plaque_2_mod_blanc_078802L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6842044 | Installations électriques | Legrand_Mosaic_plaque_2_mod_blanc_078802L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 676763 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2_mod_blanc_078802L | Legrand_Mosaic_plaque_2_mod_blanc_078802L | Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000380515 m3; Surface: 0.00659947 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Fabricant: Legrand; Largeur: 0.082 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078802L; EAN: 3414971577756; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078802L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
603_DETECTEUR PD4-M-1C-C-PS | Family | 603_DETECTEUR PD4-M-1C-C-PS | N0_FINI
CATALOGUE DE TYPE | Type | CATALOGUE DE TYPE | N0_FINI
603_DETECTEUR PD4-M-1C-C-PS | CATALOGUE DE TYPE | 603_DETECTEUR PD4-M-1C-C-PS | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5548341 | Installations électriques | CATALOGUE DE TYPE | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5044805 | 0 | Installations électriques | 0 | Famille : Installations électriques : 603_DETECTEUR PD4-M-1C-C-PS | 603_DETECTEUR PD4-M-1C-C-PS | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Identifiant: 1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.47 m; Niveau de nomenclature: N0_FINI; ZZZ_X_Length: 0.0505 m; ZZZ_Y_Length: 0.0505 m; ZZZ_Suspension_height_02_Length: 0 m; ZZZ_Logo LOD400_YesNo: no; ZZZ_Logo LOD200_YesNo: yes; ZZZ_Suspension_height_03_Length: 0 m; ZZZ_SOg_3D_gen_YesNo: no; ZZZ_Suspension_height_01_Length: 0 m; ZZZ_Detection zone_3D_type_FamilyType_Lighting Devices: standard; Cotes - Volume: 0.00946941 m3; Surface: 0.468618 m2; Electricité - Charges - Panneau: TD1-Q23-BD8; Numero de circuit: 2; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.15; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: MOVEMENTSENSOR; Fabricant: B.E.G.; Modèle: capteur de mouvement; URL: -; Description: capteur de mouvement; Exporter le type au format IFC sous: IfcAirTerminalType; Couleur: -; Code d'assemblage: 62.60.10; IfcExportAs: IfcAirTerminalType; IfcExportType: MOVEMENTSENSOR; RSen_C_content_date_issue: 29/09/2023; ZZZ_Cut out_X_Length: 0 m; ZZZ_Logo_Z_Length: 0 m; ZZZ_Height_Width_Length: 0.076 m; ZZZ_Width_Length: 0.101 m; ZZZ_Suspension_YesNo: no; ZZZ_Cut out_Y_Length: 0 m; ZZZ_Const_06_Length: 0 m; ZZZ_Width_Height_Length: 0.101 m; ZZZ_Recessed_YesNo: no; ZZZ_Cut out_length_Length: 0 m; ZZZ_Const_05_Length: 0 m; ZZZ_Parallel wall mounted_YesNo: no; ZZZ_Const_04_Length: 0 m; ZZZ_Logo_plane_Integer: 2; ZZZ_Detection zone_rotation_Angle: 0 deg; ZZZ_Mounted_ceiling_YesNo: no; ZZZ_Logo_Y_Length: 0 m; ZZZ_Cut out_length__Length: 0.001 m; ZZZ_Detection zone_X_Length: 0 m; ZZZ_Cut out_height_Length: 0 m; ZZZ_Cut out_width__Length: 0.001 m; ZZZ_Pendant - vertical mounted_YesNo: no; ZZZ_Logo_X_Length: 0 m; ZZZ_Zones_plane_Integer: 2; ZZZ_Cut out_width_Length: 0 m; ZZZ_Const_03_Length: 0 m; ZZZ_Displacement_Y_Length: 0 m; ZZZ_Height negative_Length: -0.076 m; ZZZ_Height_Length: 0.076 m; ZZZ_Detection zone_plane_Integer: 1; ZZZ_Detection zone_Z_Length: 0 m; ZZZ_Pendant - horizontal mounted_YesNo: no; ZZZ_Logo_Rotation about axis_Angle: 180 deg; ZZZ_Cut out_diameter_Length: 0 m; ZZZ_Surface mounted_YesNo: yes; ZZZ_IP_YesNo: no; ZZZ_Recess depth_Length: 0 m; ZZZ_Mounted_wall_YesNo: yes; ZZZ_Angled wall mounted_YesNo: no; ZZZ_Cut out_radius_Length: 0.001 m; ZZZ_Detection zone_Y_Length: 0 m; ZZZ_Cut out_height negative_Length: -0.002 m; ZZZ_Const_01_Length: 0 m; ZZZ_Length_Length: 0.101 m; ZZZ_Const_02_Length: 0 m; ZZZ_Placeholder for SOg_FamilyType_Lighting Devices: aucun; ZZZ_Detection zone_3D_standard_FamilyType_Lighting Devices: standard; ZZZ_Visualized connectors_FamilyType_Generic Models: standard; ZZZ_Detection zone_3D_none_FamilyType_Lighting Devices: standard; ZZZ_Bounding Box_FamilyType_Lighting Devices: standard; ZZZ_Annotation_FamilyType_Generic Annotations: standard; ZZZ_V Component_02_X_Length: 0 m; ZZZ_V Component_01_width_Length: 0 m; ZZZ_V E_c01_Z_Length: 0 m; ZZZ_V Component_03_width_Length: 0 m; ZZZ_V Clearance zone_bottom_Length: 0 m; ZZZ_V Component_03_Y_Length: 0 m; ZZZ_V Component_01_Z_Length: 0 m; ZZZ_V Component_03_length_Length: 0 m; ZZZ_V Component_03_height_Length: 0 m; ZZZ_V Clearance zone_top_Length: 0 m; ZZZ_V Light sensor_YesNo: no; ZZZ_V E_c01_Y_Length: 0 m; ZZZ_V Detection range at height_Length: 2.5 m; ZZZ_V Detection range_02_max height_Length: 5 m; ZZZ_V Suspension_plane_Integer: 2; ZZZ_V Component_01_plane_Integer: 1; ZZZ_V Component_03_diameter_Length: 0 m; ZZZ_V SOg_plane_Integer: 2; ZZZ_V Component_02_width_Length: 0 m; ZZZ_V Detection zone_03_material_Material: RSfr_x_rgb 000 128 000 T80 vert_gen; ZZZ_V Clearance zone_material_Material: RSfr_x_rgb 255 128 128 T80 rouge_gen; ZZZ_V Detection angle_Angle: 360 deg; ZZZ_V Detection range_01_Length: 40 m; ZZZ_V Component_02_Z_Length: 0 m; ZZZ_V SOg_X_Length: 0 m; ZZZ_V Component_03_Z_Length: 0 m; ZZZ_V Clearance zone_right_Length: 0 m; ZZZ_V SOg_Y_Length: 0 m; ZZZ_V Component_01_length_Length: 0 m; ZZZ_V Ventilation control_YesNo: no; ZZZ_V Component_03_plane_Integer: 1; ZZZ_V Component_01_height_Length: 0.076 m; ZZZ_V Suspension_Y_Length: 0 m; ZZZ_V Component_02_Y_Length: 0 m; ZZZ_V IP_Integer: 0; ZZZ_V Component_01_X_Length: 0 m; ZZZ_V E_c01_plane_Integer: 1; ZZZ_V Detection range_01_max height_Length: 5 m; ZZZ_V Component_02_length_Length: 0 m; ZZZ_V Detection range_03_max height_Length: 3.5 m; ZZZ_V Component_02_height_Length: 0 m; ZZZ_V E_c01_X_Length: 0 m; ZZZ_V Clearance zone_back_Length: 0 m; ZZZ_V Clearance zone_front_Length: 0 m; ZZZ_V Detection range_03_Length: 5 m; ZZZ_V Component_03_X_Length: 0 m; ZZZ_V Component_02_description_Text: -; ZZZ_V Detection range_02_Length: 7 m; ZZZ_V Component_02_diameter_Length: 0 m; ZZZ_V SOg_rotation_Angle: 0 deg; ZZZ_V Suspension_offset_Length: 0 m; ZZZ_V Suspension_width_Length: 0 m; ZZZ_V Component_01_diameter_Length: 0.101 m; ZZZ_V Dimmer_YesNo: no; ZZZ_V Component_03_description_Text: -; ZZZ_V SOg_Z_Length: 0 m; ZZZ_V Suspension_X_Length: 0 m; ZZZ_V Component_02_plane_Integer: 2; ZZZ_V Suspension_min_Length: 0 m; ZZZ_V Detection zone_02_material_Material: RSfr_x_rgb 000 128 255 T80 bleu_gen; ZZZ_V Component_01_description_Text: détecteur; ZZZ_V Suspension_max_Length: 0 m; ZZZ_V Component_01_Y_Length: 0 m; ZZZ_V Detection zone_01_material_Material: RSfr_x_rgb 255 128 128 T80 rouge_gen; ZZZ_V Clearance zone_left_Length: 0 m; ZZZ_V Suspension_length_Length: 0 m; ZZZ_V Suspension_type_FamilyType_Lighting Devices: aucun_gen; RSfr_C_type: capteur de mouvement; RSfr_C_content_version: 1.0.0; RSfr_C_revit_version: 2020; TBQfr_C_licence_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; RSfr_C_code_gtin: -; RSfr_C_type_commentaires: capteur de mouvement; RSfr_C_code_ETIM_url: http://prod.etim-international.com/; RSfr_C_content_date_modifié: 29/09/2023; TBQfr_C_code_produit: -; RSfr_C_content_fournisseur: B.E.G.; RSfr_C_content_créateur: © ThorbiQ; RSfr_C_description: capteur de mouvement; RSfr_C_code_article: -; TBQfr_C_IFC_version: 2x3; RSfr_C_code_classe_de_produit: -; RSfr_C_modèle: capteur de mouvement; TBQfr_C_licence: Creative Commons Attribution NoDerivs (CC-ND); RSfr_C_largeur: 0 m; RSfr_C_hauteur: 0.076 m; TBQfr_C_SOg_LD_2D: aucun; TBQfr_C_accessoires_EE_02: aucun_gen; TBQfr_C_accessoires_EE_05: aucun_gen; RSfr_E_c01_puissance_apparente: 0 VA; RSfr_E_c01_nombre_de_pôles: 1; TBQfr_C_accessoires_EE_03: aucun_gen; RSfr_C_longueur: 0 m; RSfr_E_c01_tension: 230 V; TBQfr_E_c01_oui_non: yes; TBQfr_C_SOg_LD_3D: aucun; TBQfr_C_accessoires_EE_04: aucun_gen; RSfr_C_diamètre: 0.101 m; RSfr_E_c01_sous_indice_de_charge_moteur: no; TBQfr_C_accessoire_01_description: -; RSfr_E_c01_description: -; TBQfr_E_c01_type_de_système: -; TBQ_I BaseKeynote: 62.60.10; TBQ_I Domaine de saisie des données: -; TBQ_I Maître: yes; TBQ_I Esclave: no; TBQ_I Type de sortie: -; Scénario: -; Dimensions du bloc d'alimentation externe: -; Puissance interne W: -; Absorption de courant mA: -; Réglages: -; Surface contrôlée approche tangentielle m² à une hauteur de montage de 2,5 m: -; Hauteur de montage Min. m: -; Hauteur de montage Max. m: -; Hauteur de montage Recommandé m: -; Mesurage du lumière: -; Évaluation de la température: -; Boîtier: -; Longeur de cable cm: -; KNX Nombre de capteurs de luminosité: -; KNX Nombre de capteurs PIR: -; KNX TP 256: -; Canal 01: -; Canal 01 Puissance: -; Canal 01 Lumière d’orientation: -; Canal 01 Nachtlicht: -; Canal 02: -; Canal 02 Puissance: -; Canal 02 Durée de temporisation: -; Canal 02 Lumière d’orientation: -; Canal 02 Seuil d´enchlenchement Lux: -; Détecteur Largeur en mm: -; Détecteur Hauteur en mm: -; Détecteur Profondeur en mm: -; Graphismes - ZZZ_V Position annotation x_Integer: 0; ZZZ_V Position annotation y_Integer: 0; ZZZ_V Displacement annotation y_Length: 0 m; ZZZ_V Displacement annotation x_Length: 0 m; TBQfr_C_zone_libre: no; TBQfr_C_portée_02_description: Frontale; TBQfr_C_portée_01_description: Transversale; TBQfr_C_logo: yes; TBQfr_C_portée_01: no; TBQfr_C_portée_02: no; TBQfr_C_portée_03_description: Activité assise; TBQfr_C_portée_03: no; Construction - ZZZ_V Suspension_height_Length: 0 m; TBQfr_C_alignement: Centre; TBQfr_C_GOg: yes; TBQfr_C_accessoires_EE_01: aucun_gen; TBQfr_C_alignement_index: 0; TBQfr_C_SOg: no; TBQfr_C_hauteur_de_montage: 2.5 m; Electrique - TBQfr_E_facteur_de_puissance: 1; TBQfr_E_c01_facteur_de_puissance: 1; RSfr_E_c01_indice_de_charge: Other
2 x 603_DETECTEUR PD4-M-1C-C-PS | Instance | 603_DETECTEUR PD4-M-1C-C-PS | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5044805 | Installations électriques |  |  | Famille : Installations électriques : 603_DETECTEUR PD4-M-1C-C-PS | Autre - Nom de la famille: 603_DETECTEUR PD4-M-1C-C-PS; ZZZ_V E_c01_Z_Length: 0 m; ZZZ_V E_c01_Y_Length: 0 m; ZZZ_V E_c01_plane_Integer: 1; ZZZ_V E_c01_X_Length: 0 m; TBQfr_E_c01_oui_non: yes; RSfr_E_c01_description: -; TBQfr_E_c01_type_de_système: -; Données d'identification - Nom du type: CATALOGUE DE TYPE; Note d'identification: 600_ELECTRICITE C.FORTS; Modèle: capteur de mouvement; Fabricant: B.E.G.; URL: -; Description: capteur de mouvement; Code d'assemblage: 62.60.10; RSen_C_content_date_issue: 29/09/2023; RSfr_C_type: capteur de mouvement; RSfr_C_content_version: 1.0.0; RSfr_C_revit_version: 2020; TBQfr_C_licence_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; RSfr_C_code_gtin: -; RSfr_C_type_commentaires: capteur de mouvement; RSfr_C_code_ETIM_url: http://prod.etim-international.com/; RSfr_C_content_date_modifié: 29/09/2023; TBQfr_C_code_produit: -; RSfr_C_content_fournisseur: B.E.G.; RSfr_C_content_créateur: © ThorbiQ; RSfr_C_description: capteur de mouvement; RSfr_C_code_article: -; TBQfr_C_IFC_version: 2x3; RSfr_C_code_classe_de_produit: -; RSfr_C_modèle: capteur de mouvement; TBQfr_C_licence: Creative Commons Attribution NoDerivs (CC-ND); TBQfr_C_accessoire_01_description: -; TBQ_I BaseKeynote: 62.60.10; Contraintes - Elévation par défaut: 0 m; ZZZ_Cut out_X_Length: 0 m; ZZZ_Logo_Z_Length: 0 m; ZZZ_Height_Width_Length: 0.076 m; ZZZ_Width_Length: 0.101 m; ZZZ_Suspension_YesNo: no; ZZZ_Cut out_Y_Length: 0 m; ZZZ_Const_06_Length: 0 m; ZZZ_Width_Height_Length: 0.101 m; ZZZ_Recessed_YesNo: no; ZZZ_Cut out_length_Length: 0 m; ZZZ_Const_05_Length: 0 m; ZZZ_Parallel wall mounted_YesNo: no; ZZZ_Const_04_Length: 0 m; ZZZ_Logo_plane_Integer: 2; ZZZ_Detection zone_rotation_Angle: 0 deg; ZZZ_Mounted_ceiling_YesNo: no; ZZZ_Logo_Y_Length: 0 m; ZZZ_Cut out_length__Length: 0.001 m; ZZZ_Detection zone_X_Length: 0 m; ZZZ_Cut out_height_Length: 0 m; ZZZ_Cut out_width__Length: 0.001 m; ZZZ_Pendant - vertical mounted_YesNo: no; ZZZ_Logo_X_Length: 0 m; ZZZ_Zones_plane_Integer: 2; ZZZ_Cut out_width_Length: 0 m; ZZZ_Const_03_Length: 0 m; ZZZ_Displacement_Y_Length: 0 m; ZZZ_Height negative_Length: -0.076 m; ZZZ_Height_Length: 0.076 m; ZZZ_Detection zone_plane_Integer: 1; ZZZ_Detection zone_Z_Length: 0 m; ZZZ_Pendant - horizontal mounted_YesNo: no; ZZZ_Logo_Rotation about axis_Angle: 180 deg; ZZZ_Cut out_diameter_Length: 0 m; ZZZ_Surface mounted_YesNo: yes; ZZZ_IP_YesNo: no; ZZZ_Recess depth_Length: 0 m; ZZZ_Mounted_wall_YesNo: yes; ZZZ_Angled wall mounted_YesNo: no; ZZZ_Cut out_radius_Length: 0.001 m; ZZZ_Detection zone_Y_Length: 0 m; ZZZ_Cut out_height negative_Length: -0.002 m; ZZZ_Const_01_Length: 0 m; ZZZ_Length_Length: 0.101 m; ZZZ_Const_02_Length: 0 m; ZZZ_Placeholder for SOg_FamilyType_Lighting Devices: aucun; ZZZ_Detection zone_3D_standard_FamilyType_Lighting Devices: standard; ZZZ_Visualized connectors_FamilyType_Generic Models: standard; ZZZ_Detection zone_3D_none_FamilyType_Lighting Devices: standard; ZZZ_Bounding Box_FamilyType_Lighting Devices: standard; ZZZ_Annotation_FamilyType_Generic Annotations: standard; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: MOVEMENTSENSOR; Exporter le type au format IFC sous: IfcAirTerminalType; IfcExportAs: IfcAirTerminalType; IfcExportType: MOVEMENTSENSOR; Construction - ZZZ_V Component_02_X_Length: 0 m; ZZZ_V Component_01_width_Length: 0 m; ZZZ_V Component_03_width_Length: 0 m; ZZZ_V Component_03_Y_Length: 0 m; ZZZ_V Component_01_Z_Length: 0 m; ZZZ_V Component_03_length_Length: 0 m; ZZZ_V Component_03_height_Length: 0 m; ZZZ_V Suspension_plane_Integer: 2; ZZZ_V Component_01_plane_Integer: 1; ZZZ_V Component_03_diameter_Length: 0 m; ZZZ_V SOg_plane_Integer: 2; ZZZ_V Component_02_width_Length: 0 m; ZZZ_V Component_02_Z_Length: 0 m; ZZZ_V SOg_X_Length: 0 m; ZZZ_V Component_03_Z_Length: 0 m; ZZZ_V SOg_Y_Length: 0 m; ZZZ_V Component_01_length_Length: 0 m; ZZZ_V Component_03_plane_Integer: 1; ZZZ_V Component_01_height_Length: 0.076 m; ZZZ_V Suspension_Y_Length: 0 m; ZZZ_V Component_02_Y_Length: 0 m; ZZZ_V Component_01_X_Length: 0 m; ZZZ_V Component_02_length_Length: 0 m; ZZZ_V Component_02_height_Length: 0 m; ZZZ_V Component_03_X_Length: 0 m; ZZZ_V Component_02_description_Text: -; ZZZ_V Component_02_diameter_Length: 0 m; ZZZ_V SOg_rotation_Angle: 0 deg; ZZZ_V Suspension_offset_Length: 0 m; ZZZ_V Suspension_width_Length: 0 m; ZZZ_V Component_01_diameter_Length: 0.101 m; ZZZ_V Component_03_description_Text: -; ZZZ_V SOg_Z_Length: 0 m; ZZZ_V Suspension_X_Length: 0 m; ZZZ_V Component_02_plane_Integer: 2; ZZZ_V Component_01_description_Text: détecteur; ZZZ_V Component_01_Y_Length: 0 m; ZZZ_V Suspension_length_Length: 0 m; ZZZ_V Suspension_type_FamilyType_Lighting Devices: aucun_gen; TBQfr_C_SOg_LD_2D: aucun; TBQfr_C_accessoires_EE_02: aucun_gen; TBQfr_C_accessoires_EE_05: aucun_gen; TBQfr_C_accessoires_EE_03: aucun_gen; TBQfr_C_SOg_LD_3D: aucun; TBQfr_C_accessoires_EE_04: aucun_gen; Graphismes - ZZZ_V Clearance zone_bottom_Length: 0 m; ZZZ_V Clearance zone_top_Length: 0 m; ZZZ_V Clearance zone_right_Length: 0 m; ZZZ_V Clearance zone_back_Length: 0 m; ZZZ_V Clearance zone_front_Length: 0 m; ZZZ_V Clearance zone_left_Length: 0 m; Propriétés du modèle - ZZZ_V Light sensor_YesNo: no; ZZZ_V Detection range at height_Length: 2.5 m; ZZZ_V Detection range_02_max height_Length: 5 m; ZZZ_V Detection angle_Angle: 360 deg; ZZZ_V Detection range_01_Length: 40 m; ZZZ_V Ventilation control_YesNo: no; ZZZ_V IP_Integer: 0; ZZZ_V Detection range_01_max height_Length: 5 m; ZZZ_V Detection range_03_max height_Length: 3.5 m; ZZZ_V Detection range_03_Length: 5 m; ZZZ_V Detection range_02_Length: 7 m; ZZZ_V Dimmer_YesNo: no; ZZZ_V Suspension_min_Length: 0 m; ZZZ_V Suspension_max_Length: 0 m; TBQ_I Domaine de saisie des données: -; TBQ_I Maître: yes; TBQ_I Esclave: no; TBQ_I Type de sortie: -; Scénario: -; Couleur: -; Dimensions du bloc d'alimentation externe: -; Puissance interne W: -; Absorption de courant mA: -; Réglages: -; Surface contrôlée approche tangentielle m² à une hauteur de montage de 2,5 m: -; Hauteur de montage Min. m: -; Hauteur de montage Max. m: -; Hauteur de montage Recommandé m: -; Mesurage du lumière: -; Évaluation de la température: -; Boîtier: -; Longeur de cable cm: -; KNX Nombre de capteurs de luminosité: -; KNX Nombre de capteurs PIR: -; KNX TP 256: -; Canal 01: -; Canal 01 Puissance: -; Canal 01 Lumière d’orientation: -; Canal 01 Nachtlicht: -; Canal 02: -; Canal 02 Puissance: -; Canal 02 Durée de temporisation: -; Canal 02 Lumière d’orientation: -; Canal 02 Seuil d´enchlenchement Lux: -; Détecteur Largeur en mm: -; Détecteur Hauteur en mm: -; Détecteur Profondeur en mm: -; Matériaux et finitions - ZZZ_V Detection zone_03_material_Material: RSfr_x_rgb 000 128 000 T80 vert_gen; ZZZ_V Clearance zone_material_Material: RSfr_x_rgb 255 128 128 T80 rouge_gen; ZZZ_V Detection zone_02_material_Material: RSfr_x_rgb 000 128 255 T80 bleu_gen; ZZZ_V Detection zone_01_material_Material: RSfr_x_rgb 255 128 128 T80 rouge_gen; Cotes - RSfr_C_largeur: 0 m; RSfr_C_hauteur: 0.076 m; RSfr_C_longueur: 0 m; RSfr_C_diamètre: 0.101 m; Electrique - RSfr_E_c01_puissance_apparente: 0 VA; RSfr_E_c01_nombre_de_pôles: 1; RSfr_E_c01_tension: 230 V; RSfr_E_c01_sous_indice_de_charge_moteur: no
