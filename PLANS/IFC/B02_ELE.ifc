Properties of the parts of a building model (IFC4), part 9 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158385 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5796071 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q9; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.5 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.0410496 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 9; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 0 A; Courant de Phase B: 0 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 0 A; Intensité installée totale: 0 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 0 VA; Puissance apparente installée totale: 0 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 0 VA; Puissance apparente requise Autre: 0 VA; Puissance apparente connectée Autre: 0 VA; Autre - Intensité utilisée estimée: 0 A; Autre - Intensité installée: 0 A; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Nom du panneau: TD1-Q9-BD1; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: PC 230N; Texte - TEXTE 3D: TD1-Q9-BD1
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158286 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6792998 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q30; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.5 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411579 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 2; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 3 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 760 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 0 A; Courant de Phase B: 3 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 3 A; Intensité installée totale: 3 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 760 VA; Puissance apparente installée totale: 760 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 760 VA; Puissance apparente - Phase A: 0 VA; PC 2P+T 230V - Puissance apparente installée: 760 VA; PC 2P+T 230V - Puissance apparente requise: 760 VA; PC 2P+T 230V - Intensité installée: 3 A; PC 2P+T 230V - Intensité requise estimée: 3 A; PC 2P+T 230V - Coefficient d'utilisation: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1-Q30-BD1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Nom du panneau: TD1-Q30-BD2; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: PC 230N; Texte - TEXTE 3D: TD1-Q30-BD2
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158448 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6793164 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q30; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.6 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411302 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 29; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 10 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 2280 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 0 A; Courant de Phase B: 10 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 10 A; Intensité installée totale: 10 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 2280 VA; Puissance apparente installée totale: 2280 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 2280 VA; Puissance apparente - Phase A: 0 VA; PC 2P+T 230V - Puissance apparente installée: 2280 VA; PC 2P+T 230V - Puissance apparente requise: 2280 VA; PC 2P+T 230V - Intensité installée: 10 A; PC 2P+T 230V - Intensité requise estimée: 10 A; PC 2P+T 230V - Coefficient d'utilisation: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Nom du panneau: TD1-Q30-BD1; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: PC 230N; Texte - TEXTE 3D: TD1-Q30-BD1
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158445 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6793490 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q29; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.5 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411396 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 30; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 10 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 2280 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 10 A; Courant de Phase B: 0 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 10 A; Intensité installée totale: 10 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 2280 VA; Puissance apparente installée totale: 2280 VA; Puissance apparente - Phase C: 2280 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 0 VA; PC 2P+T 230V - Puissance apparente installée: 2280 VA; PC 2P+T 230V - Puissance apparente requise: 2280 VA; PC 2P+T 230V - Intensité installée: 10 A; PC 2P+T 230V - Intensité requise estimée: 10 A; PC 2P+T 230V - Coefficient d'utilisation: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Nom du panneau: TD1-Q29-BD1; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: PC 230N; Texte - TEXTE 3D: TD1-Q29-BD1
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158451 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6793548 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q28; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.5 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.0411723 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 2; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 0 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 3 A; Puissance apparente du circuit de dérivation - Phase C: 0 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 760 VA; Courant de Phase C: 0 A; Courant de Phase B: 0 A; Courant de Phase A: 3 A; Intensité requise estimée totale: 3 A; Intensité installée totale: 3 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 760 VA; Puissance apparente installée totale: 760 VA; Puissance apparente - Phase C: 0 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 760 VA; PC 2P+T 230V - Puissance apparente installée: 760 VA; PC 2P+T 230V - Puissance apparente requise: 760 VA; PC 2P+T 230V - Intensité installée: 3 A; PC 2P+T 230V - Intensité requise estimée: 3 A; PC 2P+T 230V - Coefficient d'utilisation: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1-Q28-BD1; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Nom du panneau: TD1-Q28-BD2; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: PC 230N; Texte - TEXTE 3D: TD1-Q28-BD2
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158442 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
602_BOITE DE DERIVATION | 105X105X50 GENERIQUE | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6841873 | Tableaux/Baies | 105X105X50 GENERIQUE | 0 | 2021_015 | yes | yes | <non associé> | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5808740 | 1.2192 | Tableaux/Baies | 1 | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | 602_BOITE DE DERIVATION | Paramètres IFC - Type prédéfini d'IFC: POWER; Exporter au format IFC sous: IfcJunctionBoxType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q33; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: 2.6 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0000819755 m3; Surface: 0.041124 m2; Symbole de distance horizontale: 0 m; Distance du mur: 0 m; Electricité - Charges - Numero de circuit: 33; Courant des boîtes de raccordement Phase C: 0 A; Courant des boîtes de raccordement Phase B: 0 A; Courant des boîtes de raccordement Phase A: 0 A; Puissance apparente des boîtes de raccordement - Phase C: 0 VA; Puissance apparente des boîtes de raccordement - Phase B: 0 VA; Puissance apparente des boîtes de raccordement - Phase A: 0 VA; Courant du circuit de dérivation Phase C: 2 A; Courant du circuit de dérivation Phase B: 0 A; Courant du circuit de dérivation Phase A: 0 A; Puissance apparente du circuit de dérivation - Phase C: 380 VA; Puissance apparente du circuit de dérivation - Phase B: 0 VA; Puissance apparente du circuit de dérivation - Phase A: 0 VA; Courant de Phase C: 2 A; Courant de Phase B: 0 A; Courant de Phase A: 0 A; Intensité requise estimée totale: 2 A; Intensité installée totale: 2 A; Coefficient d'utilisation global: 100.00%; Puissance apparente requise totale: 380 VA; Puissance apparente installée totale: 380 VA; Puissance apparente - Phase C: 380 VA; Puissance apparente - Phase B: 0 VA; Puissance apparente - Phase A: 0 VA; Puissance apparente requise Autre: 380 VA; Puissance apparente connectée Autre: 380 VA; Autre - Intensité utilisée estimée: 2 A; Autre - Intensité installée: 2 A; Autre - Coefficient d'utilisation: 100.00%; Electricité - Circuit - Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: 0; Nombre de fils: 2; Nombre de phases: 1; Système de distribution: 230V AC; En provenance de: TD1; Type de Revit - Puissance: 0 VA; Note d'identification: 600_ELECTRICITE C.FORTS; Type: Type prédéfini d'IFC: POWER; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Fabricant: GEWISS S.p.A.; Image du type: GW44055.jpg; Modèle: GW44053R; URL: https://www.gewiss.com/it/it; Largeur: 0.105 m; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Longueur: 0.105 m; Exporter le type au format IFC sous: IfcJunctionBoxType; Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Dim. interne BxHxP (mm): 80x80x40; Catalogo Serie: 44 CE; Entrate N. fori / Ã˜: 6 / 23; Colore coperchio: Grigio RAL 7035; Temperatura di impiego: -25 +60 °C; Catalogo: BUILDING; Codice EAN: 8011564261631; SEO: Cassetta; Classe isolamento: II (secondo Norma IEC 61140); Colore cassetta: Rosso RAL 3000; Versione file RFA: 18.0; Grado di protezione: IP44; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Materiale: Tecnopolimero GWPLAST 75; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Pareti: Con passacavi; Codice Electrocod: 02210; Spessore: 0.05 m; Élément de détail: 120x80x50; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Classification: Other; Tension: 0 V; COULEUR DM: IMPORTED_RGBA(255,0,0,255); TEXTE 3D.: no; Général - Nom du panneau: TD1-Q33-BD1; Visibilité - Cadre de symbole: no; Symbole: no; VISTA DI PIANTA: yes; ELE_TYPE DE BOITE: PC 230N; Texte - TEXTE 3D: TD1-Q33-BD1
602_BOITE DE DERIVATION | Instance | 602_BOITE DE DERIVATION | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 7158460 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 602_BOITE DE DERIVATION | Autre - Nom de la famille: 602_BOITE DE DERIVATION; TEXTE 3D.: no; Données d'identification - Nom du type: 105X105X50 GENERIQUE; Note d'identification: 600_ELECTRICITE C.FORTS; Titre OmniClass: Junction Boxes; Numéro OmniClass: 23.80.30.14.24; Image du type: GW44055.jpg; Modèle: GW44053R; Fabricant: GEWISS S.p.A.; URL: https://www.gewiss.com/it/it; Description: CASS.IP44 80X80X40 P.CAVI GWT 960°C R/G; Catalogo Serie: 44 CE; Catalogo: BUILDING; Codice EAN: 8011564261631; Versione file RFA: 18.0; Scheda Tecnica: https://www.gewiss.com/it/it/search?q=GW44053R; Codice Electrocod: 02210; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Type: Type prédéfini d'IFC: POWER; Exporter le type au format IFC sous: IfcJunctionBoxType; Cotes - Longueur: 0.105 m; Largeur: 0.105 m; Dim. interne BxHxP (mm): 80x80x40; Entrate N. fori / Ã˜: 6 / 23; Pareti: Con passacavi; Spessore: 0.05 m; Rayon: 0.014 m; Distance des trous: 0.034 m; Diametro: 0.028 m; Données - Applicazione: Derivazioni speciali; Termopressione con biglia: 85 °C; Temperatura di impiego: -25 +60 °C; SEO: Cassetta; Coperchio: Basso a pressione; Accessori per ripristino isolamento: GW44622; Resistenza agli urti: IK07; Glow Wire Test: 960°C; Matériaux et finitions - Colore coperchio: Grigio RAL 7035; Colore cassetta: Rosso RAL 3000; Materiale: Tecnopolimero GWPLAST 75; Couvercle: GEWISS COPERCHIO; Boite: GEWISS SCATOLA; COULEUR DM: IMPORTED_RGBA(255,0,0,255); Electrique - Classe isolamento: II (secondo Norma IEC 61140); Electricité - Circuit - Grado di protezione: IP44; Visibilité - Élément de détail: 120x80x50; Electricité - Charges - Classification: Other; Puissance: 0 VA; Electrotechnique - Tension: 0 V
612_REPARTITEUR RTD 96 PORTS | Family | 612_REPARTITEUR RTD 96 PORTS | N0_FINI
612_REPARTITEUR RTD 96 PORTS | Type | 612_REPARTITEUR RTD 96 PORTS | N0_FINI
612_REPARTITEUR RTD 96 PORTS | 612_REPARTITEUR RTD 96 PORTS | 612_REPARTITEUR RTD 96 PORTS | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5730442 | Tableaux/Baies | 612_REPARTITEUR RTD 96 PORTS | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 5607092 | 1.2192 | Tableaux/Baies | 0 | Famille : Tableaux/Baies : 612_REPARTITEUR RTD 96 PORTS | 612_REPARTITEUR RTD 96 PORTS | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: SWITCHBOARD; Exporter au format IFC sous: IfcDistributionBoardType; Données d'identification - GEM_ELE_NOM TABLEAU: BAIE RTD; Contraintes - Niveau: N0_FINI; Élévation par rapport au niveau: -6.04967e-14 m; Niveau de nomenclature: N0_FINI; Cotes - Volume: 0.0273961 m3; Surface: 6.38771 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.22; Type de Revit - Note d'identification: 610_ELECTRICITE C.FAIBLES; NUMERO DE CONNECTEUR: PB1 - PORT 1; Général - Emplacement: TGBT DC-N0-014; Nom du panneau: BAIE RTD
612_REPARTITEUR RTD 96 PORTS | Instance | 612_REPARTITEUR RTD 96 PORTS | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5607092 | Tableaux/Baies |  |  | Famille : Tableaux/Baies : 612_REPARTITEUR RTD 96 PORTS | Autre - Nom de la famille: 612_REPARTITEUR RTD 96 PORTS; Données d'identification - Nom du type: 612_REPARTITEUR RTD 96 PORTS; Note d'identification: 610_ELECTRICITE C.FAIBLES; Contraintes - Elévation par défaut: 1.2192 m; Paramètres IFC - Exporter le type au format IFC: 0; Texte - NUMERO DE CONNECTEUR: PB1 - PORT 1
Installations électriques | Category | Installations électriques | N0_FINI
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Family | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI
INTERRUPTEUR SA + PC 2P+T 230V | Type | INTERRUPTEUR SA + PC 2P+T 230V | N0_FINI
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR SA + PC 2P+T 230V | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750549 | Installations électriques | INTERRUPTEUR SA + PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1546975 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Élévation par rapport au niveau: 1.1 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: yes; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR SA + PC 2P+T 230V | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750570 | Installations électriques | INTERRUPTEUR SA + PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1546975 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Élévation par rapport au niveau: 1.1 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: yes; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR SA + PC 2P+T 230V | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750669 | Installations électriques | INTERRUPTEUR SA + PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1546975 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Élévation par rapport au niveau: 1.1 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: yes; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR SA + PC 2P+T 230V | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750713 | Installations électriques | INTERRUPTEUR SA + PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1546975 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Élévation par rapport au niveau: 1.1 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: yes; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR SA + PC 2P+T 230V | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750760 | Installations électriques | INTERRUPTEUR SA + PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1546975 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Élévation par rapport au niveau: 1.1 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: yes; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR SA + PC 2P+T 230V | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750806 | Installations électriques | INTERRUPTEUR SA + PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1546975 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Élévation par rapport au niveau: 1.1 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: yes; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR SA + PC 2P+T 230V | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750849 | Installations électriques | INTERRUPTEUR SA + PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1546975 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Élévation par rapport au niveau: 1.1 m; Se déplace avec les éléments voisins: no; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.22; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: yes; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR SA + PC 2P+T 230V | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751009 | Installations électriques | INTERRUPTEUR SA + PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1546975 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Élévation par rapport au niveau: 1.1 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: yes; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR SA + PC 2P+T 230V | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751066 | Installations électriques | INTERRUPTEUR SA + PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1546975 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Élévation par rapport au niveau: 1.1 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: yes; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no
603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | INTERRUPTEUR SA + PC 2P+T 230V | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5416217 | Installations électriques | INTERRUPTEUR SA + PC 2P+T 230V | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1546975 | 1.0645 | Installations électriques | 0 | Famille : Installations électriques : 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | 603_2POSTES_VERTICAUX_CLS_PUI_LEGRAND | Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Élévation par rapport au niveau: 1.1 m; Se déplace avec les éléments voisins: no; Type de Revit - Décalage saillie: 0 m; Flush mounting box: Legrand_Batibox_cloison_sèche_prof_40_2_postes_4_5_mod_vertical_080042; Plate: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Support frame type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Module 1: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Module 2: Legrand_Mosaic_vide; Module 3: Legrand_Mosaic_prise_2P+T_FB_surface_2_mod_blanc_077111L; Module 4: Legrand_Mosaic_vide; Module 5: Legrand_Mosaic_vide; Module 6: Legrand_Mosaic_vide; Module 7: Legrand_Mosaic_vide; Module 8: Legrand_Mosaic_vide; Module 9: Legrand_Mosaic_vide; Module 10: Legrand_Mosaic_vide; Module 11: Legrand_Mosaic_vide; Module 12: Legrand_Mosaic_vide; Module 13: Legrand_Mosaic_vide; Module 14: Legrand_Mosaic_vide; Module 15: Legrand_Mosaic_vide; Module 16: Legrand_Mosaic_vide; Module 17: Legrand_Mosaic_vide; Module 18: Legrand_Mosaic_vide; Module 19: Legrand_Mosaic_vide; Module 20: Legrand_Mosaic_vide; VV: no; SA: yes; SA+V: no; VV+V: no; SA+TEMPO: no; BP: no; BP+V: no; SA+V X2: no; SA X2: no; BP X2: no; BP+V X2: no; VV+V X2: no; VV X2: no; RJ45 + PC 230V: no
