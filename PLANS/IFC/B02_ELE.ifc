Properties of the parts of a building model (IFC4), part 11 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840567 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840595 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Instance | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802748 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Autre - Nom de la famille: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Classe Etim: EC002948 support pour installation domotique modulaire; Données d'identification - Nom du type: Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.145 m; Hauteur: 0.077 m; Profondeur: 0.0157 m; Electrique - Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840613 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840631 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5416219 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5525168 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5554001 | Installations électriques | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536501 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | Legrand_Batibox_support_2_postes_4_5_mod_vertical_080252 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000165013 m3; Surface: 0.00662205 m2; Type de Revit - Fabricant: Legrand; Largeur: 0.145 m; Profondeur: 0.0157 m; Hauteur: 0.077 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080252; EAN: 3245060802523; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/LG-080252-WEB-R.jpg; Nombre de modules horizontaux: 5; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Family | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Type | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750552 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
17 x Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Instance | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 1536500 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Autre - Nom de la famille: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Classe Etim: EC000007 Cadre de finition; Données d'identification - Nom du type: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.153 m; Hauteur: 0.082 m; Profondeur: 0.009 m; Electrique - Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750573 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750672 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750716 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750763 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.13; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750809 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.14; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750852 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.22; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751012 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751069 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840502 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840550 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840568 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840596 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Instance | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802749 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Autre - Nom de la famille: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Classe Etim: EC000007 Cadre de finition; Données d'identification - Nom du type: Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.153 m; Hauteur: 0.082 m; Profondeur: 0.009 m; Electrique - Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840614 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4840632 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5416220 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5525169 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5554002 | Installations électriques | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 1536500 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | Legrand_Mosaic_plaque_2x2_mod_vertical_blanc_078822L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.0000699412 m3; Surface: 0.0117282 m2; Type de Revit - Fabricant: Legrand; Largeur: 0.153 m; Profondeur: 0.009 m; Hauteur: 0.082 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078822L; EAN: 3414971578067; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078822L-WEB-F.jpg; Nombre de modules horizontaux: 2; Sens de montage: Vertical; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Family | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0_FINI
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Type | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0_FINI
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750553 | Installations électriques | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 715042 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000955133 m3; Electricité - Charges - Panneau: TD1-Q23-BD4; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.036 m; Hauteur: 0.045 m; Classe Etim: EC001590 Appareillage domestique; Réf legrand: LG-077011L; EAN: 3414971575165; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077011L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 31; IK: 04; Courant nominal: 10 A; Tension nominale: 250 V; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
12 x Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Instance | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 715042 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Autre - Nom de la famille: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Classe Etim: EC001590 Appareillage domestique; Données d'identification - Nom du type: Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L; Note d'identification: 600_ELECTRICITE C.FORTS; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.045 m; Hauteur: 0.045 m; Profondeur: 0.036 m; Electrique - Réf legrand: LG-077011L; EAN: 3414971575165; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077011L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 31; IK: 04; Courant nominal: 10 A; Tension nominale: 250 V
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750574 | Installations électriques | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 715042 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000955133 m3; Electricité - Charges - Panneau: TD1-Q23-BD5; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.036 m; Hauteur: 0.045 m; Classe Etim: EC001590 Appareillage domestique; Réf legrand: LG-077011L; EAN: 3414971575165; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077011L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 31; IK: 04; Courant nominal: 10 A; Tension nominale: 250 V; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750673 | Installations électriques | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 715042 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000955133 m3; Electricité - Charges - Panneau: TD1-Q23-BD2; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.036 m; Hauteur: 0.045 m; Classe Etim: EC001590 Appareillage domestique; Réf legrand: LG-077011L; EAN: 3414971575165; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077011L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 31; IK: 04; Courant nominal: 10 A; Tension nominale: 250 V; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750717 | Installations électriques | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 715042 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000955133 m3; Electricité - Charges - Panneau: TD1-Q25-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.036 m; Hauteur: 0.045 m; Classe Etim: EC001590 Appareillage domestique; Réf legrand: LG-077011L; EAN: 3414971575165; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077011L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 31; IK: 04; Courant nominal: 10 A; Tension nominale: 250 V; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750764 | Installations électriques | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 715042 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000955133 m3; Electricité - Charges - Panneau: TD1-Q25-BD3; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.13; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.036 m; Hauteur: 0.045 m; Classe Etim: EC001590 Appareillage domestique; Réf legrand: LG-077011L; EAN: 3414971575165; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077011L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 31; IK: 04; Courant nominal: 10 A; Tension nominale: 250 V; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750810 | Installations électriques | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 715042 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000955133 m3; Electricité - Charges - Panneau: TD1-Q25-BD2; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.14; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.036 m; Hauteur: 0.045 m; Classe Etim: EC001590 Appareillage domestique; Réf legrand: LG-077011L; EAN: 3414971575165; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077011L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 31; IK: 04; Courant nominal: 10 A; Tension nominale: 250 V; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4750853 | Installations électriques | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 715042 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000955133 m3; Electricité - Charges - Panneau: TD1-Q23-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.22; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.036 m; Hauteur: 0.045 m; Classe Etim: EC001590 Appareillage domestique; Réf legrand: LG-077011L; EAN: 3414971575165; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077011L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 31; IK: 04; Courant nominal: 10 A; Tension nominale: 250 V; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751013 | Installations électriques | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 715042 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000955133 m3; Electricité - Charges - Panneau: TD1-Q25-BD5; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.036 m; Hauteur: 0.045 m; Classe Etim: EC001590 Appareillage domestique; Réf legrand: LG-077011L; EAN: 3414971575165; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077011L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 31; IK: 04; Courant nominal: 10 A; Tension nominale: 250 V; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4751070 | Installations électriques | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 715042 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000955133 m3; Electricité - Charges - Panneau: TD1-Q25-BD7; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.036 m; Hauteur: 0.045 m; Classe Etim: EC001590 Appareillage domestique; Réf legrand: LG-077011L; EAN: 3414971575165; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077011L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 31; IK: 04; Courant nominal: 10 A; Tension nominale: 250 V; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5416221 | Installations électriques | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 715042 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000955133 m3; Electricité - Charges - Panneau: TD1-Q25-BD6; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.036 m; Hauteur: 0.045 m; Classe Etim: EC001590 Appareillage domestique; Réf legrand: LG-077011L; EAN: 3414971575165; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077011L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 31; IK: 04; Courant nominal: 10 A; Tension nominale: 250 V; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5525170 | Installations électriques | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 715042 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | Legrand_Mosaic_va_et_vient_easy_led_10AX_2_mod_blanc_077011L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: TOGGLESWITCH; Exporter au format IFC sous: IfcSwitchingDeviceType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000955133 m3; Electricité - Charges - Panneau: TD1-Q23-BD3; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.036 m; Hauteur: 0.045 m; Classe Etim: EC001590 Appareillage domestique; Réf legrand: LG-077011L; EAN: 3414971575165; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077011L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 31; IK: 04; Courant nominal: 10 A; Tension nominale: 250 V; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
