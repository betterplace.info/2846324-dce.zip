Properties of the parts of a building model (IFC4), part 15 of 28

# IfcBuildingElementPart (1545)
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802070 | Installations électriques | Legrand_Batibox_support_2X10_mod_080268 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777336 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000084202 m3; Surface: 0.0310263 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Fabricant: Legrand; Largeur: 0.3035 m; Profondeur: 0.0037 m; Hauteur: 0.1515 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080268; EAN: 3245060802684; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080268-LEGRAND-1000.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4804973 | Installations électriques | Legrand_Batibox_support_2X10_mod_080268 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777336 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000084202 m3; Surface: 0.0310263 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Fabricant: Legrand; Largeur: 0.3035 m; Profondeur: 0.0037 m; Hauteur: 0.1515 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080268; EAN: 3245060802684; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080268-LEGRAND-1000.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805048 | Installations électriques | Legrand_Batibox_support_2X10_mod_080268 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777336 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000084202 m3; Surface: 0.0310263 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Fabricant: Legrand; Largeur: 0.3035 m; Profondeur: 0.0037 m; Hauteur: 0.1515 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080268; EAN: 3245060802684; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080268-LEGRAND-1000.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805549 | Installations électriques | Legrand_Batibox_support_2X10_mod_080268 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777336 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000084202 m3; Surface: 0.0310263 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Fabricant: Legrand; Largeur: 0.3035 m; Profondeur: 0.0037 m; Hauteur: 0.1515 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080268; EAN: 3245060802684; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080268-LEGRAND-1000.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805882 | Installations électriques | Legrand_Batibox_support_2X10_mod_080268 | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777336 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Batibox_support_2X10_mod_080268 | Legrand_Batibox_support_2X10_mod_080268 | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000084202 m3; Surface: 0.0310263 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Fabricant: Legrand; Largeur: 0.3035 m; Profondeur: 0.0037 m; Hauteur: 0.1515 m; Classe Etim: EC002948 support pour installation domotique modulaire; Réf legrand: LG-080268; EAN: 3245060802684; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: http://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/08/080268-LEGRAND-1000.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal et vertical; Fixation: A vis
Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Family | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | N0_FINI
Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Type | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | N0_FINI
Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798773 | Installations électriques | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777335 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000268334 m3; Surface: 0.0402622 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Fabricant: Legrand; Largeur: 0.318 m; Profondeur: 0.009 m; Hauteur: 0.167 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078828L; EAN: 3414971578159; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078828L-WEB-F.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
12 x Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Instance | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4777335 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Autre - Nom de la famille: Legrand_Mosaic_plaque_2x10_mod_blanc_078828L; Classe Etim: EC000007 Cadre de finition; Données d'identification - Nom du type: Legrand_Mosaic_plaque_2x10_mod_blanc_078828L; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.318 m; Hauteur: 0.167 m; Profondeur: 0.009 m; Electrique - Réf legrand: LG-078828L; EAN: 3414971578159; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078828L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 10; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798843 | Installations électriques | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777335 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000268334 m3; Surface: 0.0402622 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Fabricant: Legrand; Largeur: 0.318 m; Profondeur: 0.009 m; Hauteur: 0.167 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078828L; EAN: 3414971578159; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078828L-WEB-F.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799286 | Installations électriques | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777335 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000268334 m3; Surface: 0.0402622 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Fabricant: Legrand; Largeur: 0.318 m; Profondeur: 0.009 m; Hauteur: 0.167 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078828L; EAN: 3414971578159; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078828L-WEB-F.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799391 | Installations électriques | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777335 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000268334 m3; Surface: 0.0402622 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Fabricant: Legrand; Largeur: 0.318 m; Profondeur: 0.009 m; Hauteur: 0.167 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078828L; EAN: 3414971578159; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078828L-WEB-F.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799816 | Installations électriques | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777335 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000268334 m3; Surface: 0.0402622 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Fabricant: Legrand; Largeur: 0.318 m; Profondeur: 0.009 m; Hauteur: 0.167 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078828L; EAN: 3414971578159; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078828L-WEB-F.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799896 | Installations électriques | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777335 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000268334 m3; Surface: 0.0402622 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Fabricant: Legrand; Largeur: 0.318 m; Profondeur: 0.009 m; Hauteur: 0.167 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078828L; EAN: 3414971578159; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078828L-WEB-F.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802017 | Installations électriques | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777335 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000268334 m3; Surface: 0.0402622 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Fabricant: Legrand; Largeur: 0.318 m; Profondeur: 0.009 m; Hauteur: 0.167 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078828L; EAN: 3414971578159; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078828L-WEB-F.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802071 | Installations électriques | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777335 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000268334 m3; Surface: 0.0402622 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Fabricant: Legrand; Largeur: 0.318 m; Profondeur: 0.009 m; Hauteur: 0.167 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078828L; EAN: 3414971578159; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078828L-WEB-F.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4804974 | Installations électriques | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777335 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000268334 m3; Surface: 0.0402622 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Fabricant: Legrand; Largeur: 0.318 m; Profondeur: 0.009 m; Hauteur: 0.167 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078828L; EAN: 3414971578159; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078828L-WEB-F.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805049 | Installations électriques | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777335 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000268334 m3; Surface: 0.0402622 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Fabricant: Legrand; Largeur: 0.318 m; Profondeur: 0.009 m; Hauteur: 0.167 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078828L; EAN: 3414971578159; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078828L-WEB-F.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805550 | Installations électriques | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777335 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000268334 m3; Surface: 0.0402622 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Fabricant: Legrand; Largeur: 0.318 m; Profondeur: 0.009 m; Hauteur: 0.167 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078828L; EAN: 3414971578159; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078828L-WEB-F.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4805883 | Installations électriques | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4777335 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | Legrand_Mosaic_plaque_2x10_mod_blanc_078828L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Contraintes - Niveau: N0_FINI; Se déplace avec les éléments voisins: no; Cotes - Volume: 0.000268334 m3; Surface: 0.0402622 m2; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Fabricant: Legrand; Largeur: 0.318 m; Profondeur: 0.009 m; Hauteur: 0.167 m; Classe Etim: EC000007 Cadre de finition; Réf legrand: LG-078828L; EAN: 3414971578159; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-078828L-WEB-F.jpg; Nombre de modules horizontaux: 10; Sens de montage: Horizontal; Couleur: Blanc; Finition: Brillant; RAL: 9003; IP: 21; IK: 04
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Family | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Type | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798774 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q7; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q7-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
78 x Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Instance | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 921805 | Installations électriques |  |  | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Autre - Nom de la famille: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Classe Etim: EC000125 Prise de courant; Données d'identification - Nom du type: Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L; Note d'identification: 600_ELECTRICITE C.FORTS; Contraintes - Elévation par défaut: 1 m; Paramètres IFC - Exporter le type au format IFC: 0; Cotes - Largeur: 0.045 m; Hauteur: 0.045 m; Profondeur: 0.038 m; Electrique - Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Fabricant: Legrand; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798776 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q7; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q7-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798844 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q5; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q5-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4798846 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q5; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q5-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799287 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q10; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q10-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799289 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q10; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q10-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799392 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q11; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q11-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799394 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q11; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q11-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799817 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q10; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q10-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799819 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q10; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q10-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799897 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q11; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q11-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4799899 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q11; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q11-BD1; Numero de circuit: 2; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802018 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q12; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q12-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802020 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q12; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q12-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802072 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q14; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q14-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4802074 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q14; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q14-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4804975 | Installations électriques | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 921805 | 1 | Installations électriques | 0 | Famille : Installations électriques : Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | Legrand_Mosaic_prise_2P+T_FB_surface_à_détrompage_2_mod_rouge_077170L | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POWEROUTLET; Exporter au format IFC sous: IfcOutletType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q3; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Cotes - Volume: 0.0000661319 m3; Electricité - Charges - Panneau: TD1-Q3-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 250 V/1-0 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Note d'identification: 600_ELECTRICITE C.FORTS; Fabricant: Legrand; Largeur: 0.045 m; Profondeur: 0.038 m; Hauteur: 0.045 m; Classe Etim: EC000125 Prise de courant; Réf legrand: LG-077170L; EAN: 3414971576711; Conditions générales d'utilisation: https://assets.legrand.com/legal/CGU-LEGRAND-BIM-OBJECT.pdf; Photo: https://docdif.fr.grpleg.com/general/PHOTOS-WEB/LEGRAND/07/LG-077170L-WEB-F.jpg; Nombre de modules horizontaux: 2; Couleur: Rouge; Finition: Brillant; RAL: 3020; IP: 41; IK: 04; Courant nominal: 16 A; Tension nominale: 250 V; Type de puits , à puits ou surface: Surface; Standard: FB; Graphismes - Xsc: 1 m; Ysc: 1 m; Xs: 0 m; Ys: 0 m; Size Symbol: 1/50
