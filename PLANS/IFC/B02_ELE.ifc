Properties of the parts of a building model (IFC4), part 1 of 28

# File
Description: ViewDefinition [CoordinationView]
File name: B02_ELE.rvt.ifc
Time: 2025-08-25T15:16:53
Author: Mathéo Boulanger
Organization: CHU Caen
Written by: Revizto Hierarchic
Made in: ExportToIFC 5.16.5.39481

# IfcProject, CHU CAEN
Description: CHU CAEN

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 66.68 m

# IfcBuilding, B02_ELE.rvt
Description: CHU CAEN; LongName: B02_ELE.rvt; ElevationOfRefHeight: 0 m
Elément - Nom: B02_ELE.rvt; Type: Lien; Nom du fichier source: \\admin-srv2\Dir-Patr-inf\Commun\GestionPatrimoine\04_BIM\MN_PATRIMOINE\B02_DC\B02_ELE.rvt; Dernière Exportation: 2025-08-25T14:09:49; Dernier Exporté par: boulanger-mathe@chu-caen.fr
Revizto - Revizto Scene Data: base64(CAAqFDEzMzU5ODM3NTk3MDM0NDI4NDkzMlpcXGFkbWluLXNydjJcRGlyLVBhdHItaW5mXENvbW11blxHZXN0aW9uUGF0cmltb2luZVwwNF9CSU1cTU5fUEFUUklNT0lORVxCMDJfRENcQjAyX0VMRS5ydnRRw491UAMOZR1qC0IwMl9FTEUucnZ0eACAAQCIAQA=); Revizto Version: 5.16.5.39481; Revizto Scene UID: 2118114607145258947; Revizto Export Logic Version: 2

# IfcBuildingStorey (5)
In: B02_ELE.rvt
Description: Building Storey
Name | Elevation (m)
N0 | 0
N0_FINI | 0.03
S1 | -2.7
TT | 3.49
UU | 6

# IfcBuildingElementPart (1545)
In: B02_ELE.rvt
Elément - Fichier source: B02_ELE.rvt
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Famille et type = Famille = Autre, Type = ID du type = Type de Revit, Nom = Type de Revit, Nom du type | Exporter au format IFC | Données d'identification, Sous-projet | Architecture | Electrical | Hôte | Phase de création, Catégorie | Numéro de séquence | Phase de création, Nom = Phase de création | Phase de création, Sous-projet | Phase de création, Id | GEM_ROP_N°AFFAIRE | GEM_ROP_N°LOT | GEM_ROP_NOM | GEM_ROP_NOM DU LOT | Type de Revit, Id | Type de Revit, Elévation par défaut (m) | Type de Revit, Catégorie | Type de Revit, Exporter le type au format IFC | Type de Revit, Sous-projet | Type de Revit, Nom de la famille
Espaces | Category | Espaces | N0_FINI
Luminaires | Category | Luminaires | N0_FINI
604_DALLE LED 600x600MM | Family | 604_DALLE LED 600x600MM | N0_FINI
26W 4000K 3600lm | Type | 26W 4000K 3600lm | N0_FINI
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4474075 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD5; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
44 x 604_DALLE LED 600x600MM | Instance | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4677864 | Luminaires |  |  | Famille : Luminaires : 604_DALLE LED 600x600MM | Autre - Nom de la famille: 604_DALLE LED 600x600MM; Données d'identification - Nom du type: 26W 4000K 3600lm; Contraintes - Elévation par défaut: 1.2 m; Photométriques - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm; Paramètres IFC - Exporter le type au format IFC: 0
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4474076 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD5; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4474077 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Non référencée | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD5; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.11; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4474118 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD6; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4474119 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD6; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4474120 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD6; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4474121 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD6; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.10; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4474236 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q23-BD5; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4474240 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q23-BD5; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4475667 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q24; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.38 m; Élévation par rapport au niveau: 2.38 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q24-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4475675 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q24; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.38 m; Élévation par rapport au niveau: 2.38 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q24-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4475738 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q24; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.38 m; Élévation par rapport au niveau: 2.38 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q24-BD1; Numero de circuit: 3; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4475739 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q24; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.38 m; Élévation par rapport au niveau: 2.38 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q24-BD1; Numero de circuit: 3; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4475740 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q24; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.38 m; Élévation par rapport au niveau: 2.38 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q24-BD1; Numero de circuit: 3; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4475803 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q24; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.38 m; Élévation par rapport au niveau: 2.38 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q24-BD3; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4486391 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD4; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.23; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4704028 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD8; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4704053 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD8; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4704071 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD7; Numero de circuit: 2; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4704100 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD7; Numero de circuit: 2; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4704121 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD8; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4704122 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD8; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4704123 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD7; Numero de circuit: 2; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4704124 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD7; Numero de circuit: 2; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.9; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4705653 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q23-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4705654 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q23-BD2; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.21; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4705673 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q23-BD4; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4705674 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q23-BD4; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4705690 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q23-BD5; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4705691 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q23-BD5; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.18; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4705707 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q23-BD4; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4705708 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q23-BD4; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.19; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4705721 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q23-BD3; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4705722 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q23-BD3; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4705736 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q23-BD3; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 4705737 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q23; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q23-BD3; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.20; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
604_DALLE LED 600x600MM | 26W 4000K 3600lm | 604_DALLE LED 600x600MM | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5531417 | Luminaires | 26W 4000K 3600lm | 0 | 2021_015 | yes | yes | Niveau : N0_FINI | Phases | 1 | Existant | Paramètres des phases | 12589 | 2021_015 | 02 | KC | ELECTRICITE | 4677864 | 1.2 | Luminaires | 0 | Famille : Luminaires : 604_DALLE LED 600x600MM | 604_DALLE LED 600x600MM | ROP_SUIVIE DE CHANTIER - Installation ?: no; Paramètres IFC - Type prédéfini d'IFC: POINTSOURCE; Exporter au format IFC sous: IfcLightFixtureType; Données d'identification - GEM_ELE_NOM CIRCUIT: Q25; GEM_ELE_NOM TABLEAU: TD1; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.48 m; Élévation par rapport au niveau: 2.48 m; Cotes - Volume: 0.0133137 m3; Surface: 0.414039 m2; Electricité - Charges - Panneau: TD1-Q25-BD1; Numero de circuit: 1; Electricité - Circuit - Données électriques: 230 V/1-40 VA; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.3.12; Type de Revit - Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Emettre à partir de la longueur de la ligne: 0.6096 m; Gradation des changements de température de couleur de lampe: 0; Filtre de couleur: 16777215; Température initiale des couleurs: 4000 K; Eclairement: 31 lx; Intensité lumineuse: 286 cd; Efficacité: 138 lm/W; Puissance: 26 W; Fichier de distribution photométrique: RML4x14Wtl5.ies; Facteur de perte de luminosité totale: 1; Angle de l'inclinaison: -90 deg; Flux lumineux: 3600 lm
