Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
File name: B02_SSI.rvt.ifc
Time: 2025-08-27T09:04:11
Author: Mathéo Boulanger
Organization: CHU Caen
Written by: Revizto Hierarchic
Made in: ExportToIFC 5.16.5.39481

# IfcProject, CHU CAEN
Description: CHU CAEN

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 66.68 m

# IfcBuilding, B02_SSI.rvt
Description: CHU CAEN; LongName: B02_SSI.rvt; ElevationOfRefHeight: 0 m
Elément - Nom: B02_SSI.rvt; Type: Lien; Nom du fichier source: \\admin-srv2\Dir-Patr-inf\Commun\GestionPatrimoine\04_BIM\MN_PATRIMOINE\B02_DC\B02_SSI.rvt; Dernière Exportation: 2025-08-27T09:03:39; Dernier Exporté par: boulanger-mathe@chu-caen.fr
Revizto - Revizto Scene Data: base64(CAAqFDEwOTY4MjEyMzA0NzY2MTMzNDc3MlpcXGFkbWluLXNydjJcRGlyLVBhdHItaW5mXENvbW11blxHZXN0aW9uUGF0cmltb2luZVwwNF9CSU1cTU5fUEFUUklNT0lORVxCMDJfRENcQjAyX1NTSS5ydnRRW9u9AcGgkQ9qC0IwMl9TU0kucnZ0eACAAQCIAQA=); Revizto Version: 5.16.5.39481; Revizto Scene UID: 1121854533010316123; Revizto Export Logic Version: 2

# IfcBuildingStorey (5)
In: B02_SSI.rvt
Description: Building Storey
Name | Elevation (m)
N0 | 0
N0_FINI | 0.03
S1 | -2.7
TT | 3.49
UU | 6

# IfcSpace (19)
In: B02_SSI.rvt
Elément - Type: SpaceType; Fichier source: B02_SSI.rvt; Calque: N0_FINI
Informations sur le partage du travail des éléments - État des mises à jour des modèles: CurrentWithCentral; État du retrait: NotOwned; Créateur: boulanger-mathe; Dernière modification par: boulanger-mathe
Autre - Catégorie: Espaces; ID de phase: Existant
Paramètres IFC - Exporter au format IFC: 0
Données d'identification - Sous-projet: Sous-projet 1; Numéro de la pièce: Non occupé; Nom de la pièce: Non occupé
Cotes - Hauteur de calcul: 0 m; Hauteur non liée: 4 m
Revizto - Space: yes
Génie climatique - Débit - Débit de reprise: 0; Débit d'extraction réel: 0.0 m³/h; Débit de reprise réel: 0.0 m³/h; Débit de soufflage réel: 0.0 m³/h; Débit d'extraction spécifié: 0.0 m³/h; Débit de reprise spécifié: 0.0 m³/h; Débit de soufflage spécifié: 0.0 m³/h
Analyse d'énergie - Méthode de calcul d'air neuf: 0; Renouvellement d'air par heure: 0; Air neuf par surface: 0.30 L/(s·m²); Air neuf par personne: 8.5 m³/h; Informations sur l'air neuf: A partir du type d'espace; Contribution du plénum à l'éclairage: 20.00%; Zone: Par défaut; Plénum: no; Habitable: yes; Charge d'éclairage réelle par surface: 0.00 W/m²; Charge de puissance réelle par surface: 0.00 W/m²; Valeurs de charge de chauffage: -1; Unités de charge d'éclairage: 0; Unités de charge de puissance: 0; Charge de refroidissement de conception: 0 W; Charge de chauffage de conception: 0 W; Apport de chaleur sensible par personne: 73 W; Charge d'éclairage réelle: 0 W; Charge de puissance réelle: 0 W; Charge d'éclairage basée sur: -1; Charge de puissance basée sur: -1; Charge d'éclairage spécifiée par surface: 10.76 W/m²; Charge de puissance spécifiée par surface: 13.99 W/m²; Apport de chaleur latente par personne: 59 W; Apport de chaleur total par personne: 132 W; Surface par personne: 28.5714 m2; Unité d'occupation: -1; Type de condition: 2
Electricité - Eclairage - Rapport de cavité de pièce: 0; Moyenne estimée d'illumination: 0 lx; Réflectivité des sols: 20.00%; Réflexion des murs: 50.00%; Réflectivité des plafonds: 75.00%; Plan de construction du calcul de l'éclairage: 0.762 m
Electricité - Charges - Autre charge de conception par surface: 0.00 W/m²; Charge CVC de conception par surface: 0.00 W/m²
Phase de construction - Phase: Existant
Contraintes - Niveau: N0_FINI; Décalage inférieur: 0 m; Décalage limite: 4 m; Limite supérieure: N0_FINI
Name | Elément, Nom | Value = Authoring Tool Id | Données d'identification, Nom | Numéro | ELE_SSI_ZDA_ZDM | Volume (m3) | Périmètre (m) | Surface (m2) | Débit d'air neuf | Charge d'éclairage spécifiée | Charge de puissance spécifiée | Nombre de personnes
Espace 15 | Espace 15 | 6074769 | Espace | 15 | NA | 7.25458 | 6.99403 | 2.33112 | 3.3 m³/h | 25 W | 33 W | 0.0815893
BUREAU DC-N0-002 | BUREAU DC-N0-002 | 6074770 | BUREAU | DC-N0-002 | ZDM1 | 51.9554 | 18.308 | 20.9391 | 29.2 m³/h | 225 W | 293 W | 0.73287
BUREAU DC-N0-012 | BUREAU DC-N0-012 | 6074771 | BUREAU | DC-N0-012 | ZDM1 | 69.9007 | 21.4842 | 28.1751 | 39.3 m³/h | 303 W | 394 W | 0.986129
SANITAIRE DC-N0-009 | SANITAIRE DC-N0-009 | 6074772 | SANITAIRE | DC-N0-009 | ZDM1 | 10.0999 | 7.80901 | 3.2454 | 4.5 m³/h | 35 W | 45 W | 0.113589
SANITAIRE DC-N0-008 | SANITAIRE DC-N0-008 | 6074773 | SANITAIRE | DC-N0-008 | ZDM1 | 10.0649 | 7.78943 | 3.23416 | 4.5 m³/h | 35 W | 45 W | 0.113196
SANITAIRE PMR DC-N0-007 | SANITAIRE PMR DC-N0-007 | 6074774 | SANITAIRE PMR | DC-N0-007 | ZDM1 | 14.4158 | 9.66901 | 5.76631 | 8.0 m³/h | 62 W | 81 W | 0.201821
BUREAU DC-N0-003 | BUREAU DC-N0-003 | 6074775 | BUREAU | DC-N0-003 | ZDM1 | 63.534 | 20.1799 | 20.4097 | 28.5 m³/h | 220 W | 286 W | 0.714341
BOX DC-N0-005 | BOX DC-N0-005 | 6074776 | BOX | DC-N0-005 | ZDM1 | 15.4587 | 10.5747 | 6.23069 | 8.7 m³/h | 67 W | 87 W | 0.218074
BOX DC-N0-006 | BOX DC-N0-006 | 6074777 | BOX | DC-N0-006 | ZDM1 | 15.1628 | 10.1885 | 6.11135 | 8.5 m³/h | 66 W | 86 W | 0.213897
Pièce DC-N0-016 | Pièce DC-N0-016 | 6074778 | Pièce | DC-N0-016 | ZDM1 | 26.5734 | 17.0188 | 8.53715 | 11.9 m³/h | 92 W | 119 W | 0.2988
SALLE DE REUNION DC-N0-001 | SALLE DE REUNION DC-N0-001 | 6074779 | SALLE DE REUNION | DC-N0-001 | ZDM1 | 129.559 | 29.1988 | 51.5697 | 71.9 m³/h | 555 W | 722 W | 1.80494
BUREAU DC-N0-010 | BUREAU DC-N0-010 | 6074780 | BUREAU | DC-N0-010 | ZDM1 | 67.4528 | 21.3445 | 27.1881 | 37.9 m³/h | 293 W | 380 W | 0.951583
BUREAU DC-N0-011 | BUREAU DC-N0-011 | 6074781 | BUREAU | DC-N0-011 | ZDM1 | 69.9341 | 21.5086 | 28.1854 | 39.3 m³/h | 303 W | 394 W | 0.986487
Espace 28 | Espace 28 | 6074782 | Espace | 28 | ZDM1 | 4.03159 | 5.25686 | 1.68807 | 2.4 m³/h | 18 W | 24 W | 0.0590825
RESERVE DC-N0-015 | RESERVE DC-N0-015 | 6074784 | RESERVE | DC-N0-015 | ZDM1 | 13.5085 | 9.89611 | 5.44421 | 7.6 m³/h | 59 W | 76 W | 0.190547
TGBT DC-N0-014 | TGBT DC-N0-014 | 6074785 | TGBT | DC-N0-014 | ZDM1 | 9.67062 | 7.88023 | 3.86825 | 5.4 m³/h | 42 W | 54 W | 0.135389
DETENTE DC-N0-013 | DETENTE DC-N0-013 | 6074786 | DETENTE | DC-N0-013 | ZDM1 | 39.7376 | 17.0737 | 16.0146 | 22.3 m³/h | 172 W | 224 W | 0.560511
BUREAU DC-N0-004 | BUREAU DC-N0-004 | 6074787 | BUREAU | DC-N0-004 | ZDM1 | 61.3101 | 21.1404 | 24.7112 | 34.5 m³/h | 266 W | 346 W | 0.864892
Espace 34 | Espace 34 | 6074788 | Espace | 34 | NA | 37.4894 | 20.2204 | 14.3025 | 19.9 m³/h | 154 W | 200 W | 0.500587

# IfcBuildingElementPart (49)
In: B02_SSI.rvt
Elément - Fichier source: B02_SSI.rvt
Name | Elément, Type | Elément, Nom | Calque | État des mises à jour des modèles | État du retrait | Créateur = Dernière modification par | Value = Authoring Tool Id | Autre, Catégorie | Données d'identification, Sous-projet
Espaces | Category | Espaces | N0_FINI
Dispositifs d'alarme incendie | Category | Dispositifs d'alarme incendie | N0_FINI
703_DECLENCHEUR MANUEL GENERIQUE | Family | 703_DECLENCHEUR MANUEL GENERIQUE | N0_FINI
ROUGE | Type | ROUGE | N0_FINI
703_DECLENCHEUR MANUEL GENERIQUE | ROUGE | 703_DECLENCHEUR MANUEL GENERIQUE | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6030585 | Dispositifs d'alarme incendie | 2021_015 | Autre - Famille et type: ROUGE; Famille: ROUGE; Type: ROUGE; ID du type: ROUGE; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: MANUALPULLBOX; Exporter au format IFC sous: IfcAlarmType; Données d'identification - ELE_SSI_ZDA_ZDM: ZDM 1; Identifiant: 20; ELE_SSI_NOM DU DISPOSITIF: ZDM 1/1004; ELE_SSI_NUMERO DU BUS: 1; ELE_SSI_NUM DU DISPOSITIF: 004; Revizto - Electrical: yes; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 1.1 m; Cotes - Volume: 0.000456514 m3; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Electricité - Charges - Panneau: Centrale incendie; Numero de circuit: 1; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 5994086; Nom: ROUGE; Elévation par défaut: 0 m; Note d'identification: 700_SSI; Catégorie: Dispositifs d'alarme incendie; Exporter le type au format IFC: 0; Titre OmniClass: Environmental Detection/Registration; Numéro OmniClass: 23.85.30.21; Sous-projet: Famille : Dispositifs d'alarme incendie : 703_DECLENCHEUR MANUEL GENERIQUE; Nom de la famille: 703_DECLENCHEUR MANUEL GENERIQUE; Nom du type: ROUGE; COULEUR DM: IMPORTED_RGBA(255,0,0,255)
4 x 703_DECLENCHEUR MANUEL GENERIQUE | Instance | 703_DECLENCHEUR MANUEL GENERIQUE | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5994086 | Dispositifs d'alarme incendie | Famille : Dispositifs d'alarme incendie : 703_DECLENCHEUR MANUEL GENERIQUE | Autre - Nom de la famille: 703_DECLENCHEUR MANUEL GENERIQUE; Données d'identification - Note d'identification: 700_SSI; Titre OmniClass: Environmental Detection/Registration; Numéro OmniClass: 23.85.30.21; Nom du type: ROUGE; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Matériaux et finitions - COULEUR DM: IMPORTED_RGBA(255,0,0,255)
703_DECLENCHEUR MANUEL GENERIQUE | ROUGE | 703_DECLENCHEUR MANUEL GENERIQUE | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6030589 | Dispositifs d'alarme incendie | 2021_015 | Autre - Famille et type: ROUGE; Famille: ROUGE; Type: ROUGE; ID du type: ROUGE; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: MANUALPULLBOX; Exporter au format IFC sous: IfcAlarmType; Données d'identification - ELE_SSI_ZDA_ZDM: ZDM 1; Identifiant: 21; ELE_SSI_NOM DU DISPOSITIF: ZDM 2/1003; ELE_SSI_NUMERO DU BUS: 2; ELE_SSI_NUM DU DISPOSITIF: 003; Revizto - Electrical: yes; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 1.1 m; Cotes - Volume: 0.000456514 m3; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Electricité - Charges - Panneau: Centrale incendie; Numero de circuit: 1; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 5994086; Nom: ROUGE; Elévation par défaut: 0 m; Note d'identification: 700_SSI; Catégorie: Dispositifs d'alarme incendie; Exporter le type au format IFC: 0; Titre OmniClass: Environmental Detection/Registration; Numéro OmniClass: 23.85.30.21; Sous-projet: Famille : Dispositifs d'alarme incendie : 703_DECLENCHEUR MANUEL GENERIQUE; Nom de la famille: 703_DECLENCHEUR MANUEL GENERIQUE; Nom du type: ROUGE; COULEUR DM: IMPORTED_RGBA(255,0,0,255)
703_DECLENCHEUR MANUEL GENERIQUE | ROUGE | 703_DECLENCHEUR MANUEL GENERIQUE | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6030593 | Dispositifs d'alarme incendie | 2021_015 | Autre - Famille et type: ROUGE; Famille: ROUGE; Type: ROUGE; ID du type: ROUGE; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: MANUALPULLBOX; Exporter au format IFC sous: IfcAlarmType; Données d'identification - ELE_SSI_ZDA_ZDM: ZDM 2; Identifiant: 22; ELE_SSI_NOM DU DISPOSITIF: ZDM 2/1002; ELE_SSI_NUMERO DU BUS: 1; ELE_SSI_NUM DU DISPOSITIF: 002; Revizto - Electrical: yes; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 1.1 m; Cotes - Volume: 0.000456514 m3; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Electricité - Charges - Panneau: Centrale incendie; Numero de circuit: 1; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 5994086; Nom: ROUGE; Elévation par défaut: 0 m; Note d'identification: 700_SSI; Catégorie: Dispositifs d'alarme incendie; Exporter le type au format IFC: 0; Titre OmniClass: Environmental Detection/Registration; Numéro OmniClass: 23.85.30.21; Sous-projet: Famille : Dispositifs d'alarme incendie : 703_DECLENCHEUR MANUEL GENERIQUE; Nom de la famille: 703_DECLENCHEUR MANUEL GENERIQUE; Nom du type: ROUGE; COULEUR DM: IMPORTED_RGBA(255,0,0,255)
703_DECLENCHEUR MANUEL GENERIQUE | ROUGE | 703_DECLENCHEUR MANUEL GENERIQUE | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6030602 | Dispositifs d'alarme incendie | 2021_015 | Autre - Famille et type: ROUGE; Famille: ROUGE; Type: ROUGE; ID du type: ROUGE; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: MANUALPULLBOX; Exporter au format IFC sous: IfcAlarmType; Données d'identification - ELE_SSI_ZDA_ZDM: ZDM 2; Identifiant: 23; ELE_SSI_NOM DU DISPOSITIF: ZDM 2/1001; ELE_SSI_NUMERO DU BUS: 1; ELE_SSI_NUM DU DISPOSITIF: 001; Revizto - Electrical: yes; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 1.1 m; Cotes - Volume: 0.000456514 m3; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Electricité - Charges - Panneau: Centrale incendie; Numero de circuit: 1; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 5994086; Nom: ROUGE; Elévation par défaut: 0 m; Note d'identification: 700_SSI; Catégorie: Dispositifs d'alarme incendie; Exporter le type au format IFC: 0; Titre OmniClass: Environmental Detection/Registration; Numéro OmniClass: 23.85.30.21; Sous-projet: Famille : Dispositifs d'alarme incendie : 703_DECLENCHEUR MANUEL GENERIQUE; Nom de la famille: 703_DECLENCHEUR MANUEL GENERIQUE; Nom du type: ROUGE; COULEUR DM: IMPORTED_RGBA(255,0,0,255)
704_ALARME SONORE GENERIQUE | Family | 704_ALARME SONORE GENERIQUE | N0_FINI
BLANC | Type | BLANC | N0_FINI
704_ALARME SONORE GENERIQUE | BLANC | 704_ALARME SONORE GENERIQUE | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6030642 | Dispositifs d'alarme incendie | 2021_015 | Autre - Famille et type: BLANC; Famille: BLANC; Type: BLANC; ID du type: BLANC; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: SIREN; Exporter au format IFC sous: IfcAlarmType; Données d'identification - Identifiant: 25; ELE_SSI_NOM DU DISPOSITIF: N0.1; Revizto - Electrical: yes; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 2.25 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 2.25 m; Cotes - Volume: 0.000641857 m3; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Electricité - Charges - Numero de circuit: <sans nom>; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 5990972; Nom: BLANC; Elévation par défaut: 0 m; Note d'identification: 700_SSI; Catégorie: Dispositifs d'alarme incendie; Exporter le type au format IFC: 0; Titre OmniClass: Environmental Detection/Registration; Numéro OmniClass: 23.85.30.21; Sous-projet: Famille : Dispositifs d'alarme incendie : 704_ALARME SONORE GENERIQUE; Nom de la famille: 704_ALARME SONORE GENERIQUE; Nom du type: BLANC; COULEUR ALARME: Plastique blanc
704_ALARME SONORE GENERIQUE | Instance | 704_ALARME SONORE GENERIQUE | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 5990972 | Dispositifs d'alarme incendie | Famille : Dispositifs d'alarme incendie : 704_ALARME SONORE GENERIQUE | Autre - Nom de la famille: 704_ALARME SONORE GENERIQUE; Données d'identification - Note d'identification: 700_SSI; Titre OmniClass: Environmental Detection/Registration; Numéro OmniClass: 23.85.30.21; Nom du type: BLANC; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0; Matériaux et finitions - COULEUR ALARME: Plastique blanc
Tableaux/Baies | Category | Tableaux/Baies | N0_FINI
702_IROISE T4 | Family | 702_IROISE T4 | N0_FINI
702_IROISE T4 | Type | 702_IROISE T4 | N0_FINI
702_IROISE T4 | 702_IROISE T4 | 702_IROISE T4 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6355707 | Tableaux/Baies | 2021_015 | Autre - Famille et type: 702_IROISE T4; Famille: 702_IROISE T4; Type: 702_IROISE T4; ID du type: 702_IROISE T4; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: USERDEFINED; Exporter au format IFC sous: IfcAlarmType; Données d'identification - Identifiant: 32; Revizto - Electrical: yes; Architecture: yes; Contraintes - Niveau: N0_FINI; Décalage par rapport à l'hôte: 1.1 m; Hôte: Niveau : N0_FINI; Élévation par rapport au niveau: 1.1 m; Cotes - Volume: 0.00400642 m3; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 6374127; Nom: 702_IROISE T4; Elévation par défaut: 0 m; Catégorie: Tableaux/Baies; Exporter le type au format IFC: 0; Sous-projet: Famille : Tableaux/Baies : 702_IROISE T4; Nom de la famille: 702_IROISE T4; Nom du type: 702_IROISE T4; Général - Emplacement: Espace 28; Nom du panneau: Centrale incendie; Electricité - Circuit - Données électriques: 0 V/1-50 VA
702_IROISE T4 | Instance | 702_IROISE T4 | N0_FINI | CurrentWithCentral | NotOwned | boulanger-mathe | 6374127 | Tableaux/Baies | Famille : Tableaux/Baies : 702_IROISE T4 | Autre - Nom de la famille: 702_IROISE T4; Données d'identification - Nom du type: 702_IROISE T4; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemins de câbles | Category | Chemins de câbles | N0
Chemin de câbles avec raccords | Family | Chemin de câbles avec raccords | N0
Chemin de câbles à base pleine | Type | Chemin de câbles à base pleine | N0
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6284568 | Chemins de câbles | 2021_015 | Autre - Famille et type: Chemin de câbles à base pleine; Famille: Chemin de câbles à base pleine; Type: Chemin de câbles à base pleine; ID du type: Chemin de câbles à base pleine; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Revizto - Electrical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 411330; Nom: Chemin de câbles à base pleine; Catégorie: Chemins de câbles; Exporter le type au format IFC: 0; Sous-projet: Types de chemins de câbles; Nom de la famille: Chemin de câbles avec raccords; Nom du type: Chemin de câbles à base pleine; Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: no; GEM_ELE_SSI: yes; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 2; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0; Cotes - Largeur: 50 mm; Hauteur: 50 mm; Taille: 50 mmx50 mm; Longueur: 6.47866 m
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6284659 | Chemins de câbles | 2021_015 | Autre - Famille et type: Chemin de câbles à base pleine; Famille: Chemin de câbles à base pleine; Type: Chemin de câbles à base pleine; ID du type: Chemin de câbles à base pleine; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Revizto - Electrical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 411330; Nom: Chemin de câbles à base pleine; Catégorie: Chemins de câbles; Exporter le type au format IFC: 0; Sous-projet: Types de chemins de câbles; Nom de la famille: Chemin de câbles avec raccords; Nom du type: Chemin de câbles à base pleine; Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: no; GEM_ELE_SSI: yes; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0; Cotes - Largeur: 50 mm; Hauteur: 50 mm; Taille: 50 mmx50 mm; Longueur: 0.536058 m
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6284791 | Chemins de câbles | 2021_015 | Autre - Famille et type: Chemin de câbles à base pleine; Famille: Chemin de câbles à base pleine; Type: Chemin de câbles à base pleine; ID du type: Chemin de câbles à base pleine; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Revizto - Electrical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 411330; Nom: Chemin de câbles à base pleine; Catégorie: Chemins de câbles; Exporter le type au format IFC: 0; Sous-projet: Types de chemins de câbles; Nom de la famille: Chemin de câbles avec raccords; Nom du type: Chemin de câbles à base pleine; Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: no; GEM_ELE_SSI: yes; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 1; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0; Cotes - Largeur: 50 mm; Hauteur: 50 mm; Taille: 50 mmx50 mm; Longueur: 4.17443 m
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6284792 | Chemins de câbles | 2021_015 | Autre - Famille et type: Chemin de câbles à base pleine; Famille: Chemin de câbles à base pleine; Type: Chemin de câbles à base pleine; ID du type: Chemin de câbles à base pleine; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Revizto - Electrical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 411330; Nom: Chemin de câbles à base pleine; Catégorie: Chemins de câbles; Exporter le type au format IFC: 0; Sous-projet: Types de chemins de câbles; Nom de la famille: Chemin de câbles avec raccords; Nom du type: Chemin de câbles à base pleine; Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: no; GEM_ELE_SSI: yes; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 1; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0; Cotes - Largeur: 50 mm; Hauteur: 50 mm; Taille: 50 mmx50 mm; Longueur: 0.0347643 m
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6284793 | Chemins de câbles | 2021_015 | Autre - Famille et type: Chemin de câbles à base pleine; Famille: Chemin de câbles à base pleine; Type: Chemin de câbles à base pleine; ID du type: Chemin de câbles à base pleine; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Revizto - Electrical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 411330; Nom: Chemin de câbles à base pleine; Catégorie: Chemins de câbles; Exporter le type au format IFC: 0; Sous-projet: Types de chemins de câbles; Nom de la famille: Chemin de câbles avec raccords; Nom du type: Chemin de câbles à base pleine; Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: no; GEM_ELE_SSI: yes; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 1; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0; Cotes - Largeur: 50 mm; Hauteur: 50 mm; Taille: 50 mmx50 mm; Longueur: 1.88707 m
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6284824 | Chemins de câbles | 2021_015 | Autre - Famille et type: Chemin de câbles à base pleine; Famille: Chemin de câbles à base pleine; Type: Chemin de câbles à base pleine; ID du type: Chemin de câbles à base pleine; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Revizto - Electrical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 411330; Nom: Chemin de câbles à base pleine; Catégorie: Chemins de câbles; Exporter le type au format IFC: 0; Sous-projet: Types de chemins de câbles; Nom de la famille: Chemin de câbles avec raccords; Nom du type: Chemin de câbles à base pleine; Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: no; GEM_ELE_SSI: yes; Commentaires: Prevision travaux seconde partie; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0; Cotes - Largeur: 50 mm; Hauteur: 50 mm; Taille: 50 mmx50 mm; Longueur: 1.62302 m
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6284984 | Chemins de câbles | 2021_015 | Autre - Famille et type: Chemin de câbles à base pleine; Famille: Chemin de câbles à base pleine; Type: Chemin de câbles à base pleine; ID du type: Chemin de câbles à base pleine; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Revizto - Electrical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 411330; Nom: Chemin de câbles à base pleine; Catégorie: Chemins de câbles; Exporter le type au format IFC: 0; Sous-projet: Types de chemins de câbles; Nom de la famille: Chemin de câbles avec raccords; Nom du type: Chemin de câbles à base pleine; Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: no; GEM_ELE_SSI: yes; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 1; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0; Cotes - Largeur: 50 mm; Hauteur: 50 mm; Taille: 50 mmx50 mm; Longueur: 1.48276 m
Chemin de câbles avec raccords | Chemin de câbles à base pleine | Chemin de câbles avec raccords | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6588764 | Chemins de câbles | 2021_015 | Autre - Famille et type: Chemin de câbles à base pleine; Famille: Chemin de câbles à base pleine; Type: Chemin de câbles à base pleine; ID du type: Chemin de câbles à base pleine; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Revizto - Electrical: yes; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 411330; Nom: Chemin de câbles à base pleine; Catégorie: Chemins de câbles; Exporter le type au format IFC: 0; Sous-projet: Types de chemins de câbles; Nom de la famille: Chemin de câbles avec raccords; Nom du type: Chemin de câbles à base pleine; Multiplicateur de rayon de courbure: 1; Courbure horizontale: Standard; Courbure verticale extérieure: Standard; Courbure verticale intérieure: Standard; Union: Standard; Transition: Standard; Croix: Standard; Té: Standard; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: no; GEM_ELE_SSI: yes; Contraintes - Arase supérieure à son extrémité aval: 2.525 m; Arase inférieure à son extrémité amont: 2.475 m; Elévation de l'axe à son extrémité aval: 2.5 m; Elévation de l'axe à son extrémité amont: 2.5 m; Arase inférieure à son extrémité aval: 2.475 m; Arase supérieure à son extrémité amont: 2.525 m; Elévation du milieu: 2.5 m; Justification verticale: 0; Justification horizontale: 0; Élévation centrale de fin: 2.5 m; Élévation centrale de départ: 2.5 m; Niveau de référence: N0; Cotes - Largeur: 50 mm; Hauteur: 50 mm; Taille: 50 mmx50 mm; Longueur: 4.38672 m
Raccords de chemins de câbles | Category | Raccords de chemins de câbles | N0
Chemin de câbles - Courbure | Family | Chemin de câbles - Courbure | N0
2 x Standard | Type | Standard | N0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6284837 | Raccords de chemins de câbles | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Courbure ou raccord: 2; Centre à extrémité: 81 mm; Libellé sur le rayon de courbure: 75 mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Revizto - Electrical: yes; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Cotes - Volume: 0.000404052 m3; Taille: 50 mmx50 mm-50 mmx50 mm; Rayon de courbure: 50 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 1.23825 deg; l: 50 mm; h: 50 mm; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 515513; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de chemins de câbles; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure; Nom de la famille: Chemin de câbles - Courbure; Nom du type: Standard; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: no; GEM_ELE_SSI: yes; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6284838 | Raccords de chemins de câbles | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6284839 | Raccords de chemins de câbles | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Courbure ou raccord: 2; Centre à extrémité: 81 mm; Libellé sur le rayon de courbure: 75 mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Revizto - Electrical: yes; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Cotes - Volume: 0.000403557 m3; Taille: 50 mmx50 mm-50 mmx50 mm; Rayon de courbure: 50 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 1.08697 deg; l: 50 mm; h: 50 mm; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 515513; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de chemins de câbles; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure; Nom de la famille: Chemin de câbles - Courbure; Nom du type: Standard; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: no; GEM_ELE_SSI: yes; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6284834 | Raccords de chemins de câbles | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6284848 | Raccords de chemins de câbles | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Courbure ou raccord: 2; Centre à extrémité: 81 mm; Libellé sur le rayon de courbure: 75 mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Revizto - Electrical: yes; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Cotes - Volume: 0.00040578 m3; Taille: 50 mmx50 mm-50 mmx50 mm; Rayon de courbure: 50 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 1.76626 deg; l: 50 mm; h: 50 mm; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 515513; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de chemins de câbles; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure; Nom de la famille: Chemin de câbles - Courbure; Nom du type: Standard; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: no; GEM_ELE_SSI: yes; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6284843 | Raccords de chemins de câbles | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6285016 | Raccords de chemins de câbles | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Courbure ou raccord: 2; Centre à extrémité: 154 mm; Libellé sur le rayon de courbure: 75 mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: JUNCTION; Exporter au format IFC sous: IfcCableCarrierFittingType; Revizto - Electrical: yes; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Cotes - Volume: 0.000693082 m3; Taille: 50 mmx50 mm-50 mmx50 mm; Rayon de courbure: 50 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 89.5638 deg; l: 50 mm; h: 50 mm; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 515513; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de chemins de câbles; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure; Nom de la famille: Chemin de câbles - Courbure; Nom du type: Standard; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_SSI: yes; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6285017 | Raccords de chemins de câbles | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Courbure | Standard | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6588768 | Raccords de chemins de câbles | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Courbure ou raccord: 2; Centre à extrémité: 82 mm; Libellé sur le rayon de courbure: 75 mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: CABLETRAYSEGMENT; Exporter au format IFC sous: IfcCableCarrierSegmentType; Revizto - Electrical: yes; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Cotes - Volume: 0.000410451 m3; Taille: 50 mmx50 mm-50 mmx50 mm; Rayon de courbure: 50 mm; Epaisseur: 3 mm; Longueur de chemin: 80 mm; Angle: 3.19358 deg; l: 50 mm; h: 50 mm; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 515513; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de chemins de câbles; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure; Nom de la famille: Chemin de câbles - Courbure; Nom du type: Standard; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: no; GEM_ELE_SSI: yes; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Courbure | Instance | Chemin de câbles - Courbure | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6588769 | Raccords de chemins de câbles | Famille : Raccords de chemins de câbles : Chemin de câbles - Courbure | Autre - Nom de la famille: Chemin de câbles - Courbure; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
Chemin de câbles - Té | Family | Chemin de câbles - Té | N0
Chemin de câbles - Té | Standard | Chemin de câbles - Té | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6588763 | Raccords de chemins de câbles | 2021_015 | Autre - Famille et type: Standard; Famille: Standard; Type: Standard; ID du type: Standard; Libellé de rayon: 50 mm; Libellé de rayon 1: 53 mm; Paramètres IFC - Exporter au format IFC: 0; Type prédéfini d'IFC: TEE; Exporter au format IFC sous: IfcCableCarrierFittingType; Revizto - Electrical: yes; Contraintes - Niveau: N0; Élévation par rapport au niveau: 2.5 m; Cotes - Volume: 0.000928658 m3; Taille: 50 mmx50 mm-50 mmx50 mm-50 mmx50 mm; Epaisseur: 3 mm; Longueur de chemin: 50 mm; h: 50 mm; l1: 50 mm; Rayon: 50 mm; l3: 50 mm; Phase de création - Catégorie: Phases; Numéro de séquence: 1; Nom: Existant; Sous-projet: Paramètres des phases; Id: 12589; Phase de construction - Phase de création: Existant; Propriétés du modèle - GEM_ROP_LIGNE CCTP: 11.2.2; GEM_ROP_N°AFFAIRE: 2021_015; GEM_ROP_N°LOT: 02; GEM_ROP_NOM: KC; GEM_ROP_NOM DU LOT: SSI; Type de Revit - Id: 521743; Nom: Standard; Elévation par défaut: 0 m; Catégorie: Raccords de chemins de câbles; Exporter le type au format IFC: 0; Sous-projet: Famille : Raccords de chemins de câbles : Chemin de câbles - Té; Nom de la famille: Chemin de câbles - Té; Nom du type: Standard; Données d'identification - GEM_ELE_CFO: no; GEM_ELE_CFA: no; GEM_ELE_SSI: yes; Graphismes - Utiliser l'échelle d'annotations: no
Chemin de câbles - Té | Instance | Chemin de câbles - Té | N0 | CurrentWithCentral | NotOwned | boulanger-mathe | 6588813 | Raccords de chemins de câbles | Famille : Raccords de chemins de câbles : Chemin de câbles - Té | Autre - Nom de la famille: Chemin de câbles - Té; Données d'identification - Nom du type: Standard; Contraintes - Elévation par défaut: 0 m; Paramètres IFC - Exporter le type au format IFC: 0
